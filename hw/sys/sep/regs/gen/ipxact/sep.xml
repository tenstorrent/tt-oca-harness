<?xml version="1.0" encoding="UTF-8"?>
<!-- SPDX-License-Identifier: Apache-2.0 -->
<!-- SPDX-FileCopyrightText: 2026 Tenstorrent USA, Inc. -->
<!--Generated by PeakRDL IP-XACT (https://github.com/SystemRDL/PeakRDL-ipxact)-->
<ipxact:component xmlns:ipxact="http://www.accellera.org/XMLSchema/IPXACT/1685-2014" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://www.accellera.org/XMLSchema/IPXACT/1685-2014 http://www.accellera.org/XMLSchema/IPXACT/1685-2014/index.xsd">
  <ipxact:vendor>tenstorrent.com</ipxact:vendor>
  <ipxact:library>ocah</ipxact:library>
  <ipxact:name>sep_top</ipxact:name>
  <ipxact:version>1.0</ipxact:version>
  <ipxact:memoryMaps>
    <ipxact:memoryMap>
      <ipxact:name>sep_top</ipxact:name>
      <ipxact:displayName>OCAH SEP Top-Level Address Map</ipxact:displayName>
      <ipxact:description>Complete address map for OCAH Security Processor subsystem</ipxact:description>
      <ipxact:addressBlock>
        <ipxact:name>sep_sram</ipxact:name>
        <ipxact:description>SEP scratch SRAM.</ipxact:description>
        <ipxact:baseAddress>'h10000000</ipxact:baseAddress>
        <ipxact:range>'h40000</ipxact:range>
        <ipxact:width>64</ipxact:width>
        <ipxact:usage>memory</ipxact:usage>
        <ipxact:access>read-write</ipxact:access>
        <ipxact:register>
          <ipxact:name>mem_array</ipxact:name>
          <ipxact:dim>32768</ipxact:dim>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>data</ipxact:name>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>64</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>sep_boot_rom</ipxact:name>
        <ipxact:description>SEP Boot ROM Memory</ipxact:description>
        <ipxact:baseAddress>'h10040000</ipxact:baseAddress>
        <ipxact:range>'h10000</ipxact:range>
        <ipxact:width>64</ipxact:width>
        <ipxact:usage>memory</ipxact:usage>
        <ipxact:access>read-write</ipxact:access>
        <ipxact:register>
          <ipxact:name>mem_array</ipxact:name>
          <ipxact:dim>8192</ipxact:dim>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>data</ipxact:name>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>64</ipxact:bitWidth>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>secure_dma</ipxact:name>
        <ipxact:displayName>DMA Controller</ipxact:displayName>
        <ipxact:description>DMA Controller for the integrated OpenTitan.</ipxact:description>
        <ipxact:baseAddress>'h10800000</ipxact:baseAddress>
        <ipxact:range>'h150</ipxact:range>
        <ipxact:width>32</ipxact:width>
        <ipxact:register>
          <ipxact:name>INTR_STATE</ipxact:name>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>DMA_DONE</ipxact:name>
            <ipxact:description>DMA operation has been completed.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>DMA_CHUNK_DONE</ipxact:name>
            <ipxact:description>Indicates the transfer of a single chunk has been completed.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>DMA_ERROR</ipxact:name>
            <ipxact:description>DMA error has occurred. DMA_STATUS.error_code register shows the details.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_ENABLE</ipxact:name>
          <ipxact:addressOffset>'h4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>DMA_DONE</ipxact:name>
            <ipxact:description>Enable interrupt when !!INTR_STATE.dma_done is set.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>DMA_CHUNK_DONE</ipxact:name>
            <ipxact:description>Enable interrupt when !!INTR_STATE.dma_chunk_done is set.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>DMA_ERROR</ipxact:name>
            <ipxact:description>Enable interrupt when !!INTR_STATE.dma_error is set.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_TEST</ipxact:name>
          <ipxact:addressOffset>'h8</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>DMA_DONE</ipxact:name>
            <ipxact:description>Write 1 to force !!INTR_STATE.dma_done to 1.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>DMA_CHUNK_DONE</ipxact:name>
            <ipxact:description>Write 1 to force !!INTR_STATE.dma_chunk_done to 1.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>DMA_ERROR</ipxact:name>
            <ipxact:description>Write 1 to force !!INTR_STATE.dma_error to 1.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ALERT_TEST</ipxact:name>
          <ipxact:addressOffset>'hc</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>FATAL_FAULT</ipxact:name>
            <ipxact:description>Write 1 to trigger one alert event of this kind.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SRC_ADDR_LO</ipxact:name>
          <ipxact:addressOffset>'h10</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SRC_ADDR_LO</ipxact:name>
            <ipxact:description>Lower 32 bits of the source address.
Must be aligned to the transfer width.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SRC_ADDR_HI</ipxact:name>
          <ipxact:addressOffset>'h14</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SRC_ADDR_HI</ipxact:name>
            <ipxact:description>Upper 32 bits of the physical or virtual address of memory location within SoC memory address map or physical address within OT non-secure memory space.
Must be aligned to the transfer width.
Source and destination address must have the same alignment.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>DST_ADDR_LO</ipxact:name>
          <ipxact:addressOffset>'h18</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>DST_ADDR_LO</ipxact:name>
            <ipxact:description>Lower 32 bits of the destination address.
Must be aligned to the transfer width.
Source and destination address must have the same alignment.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>DST_ADDR_HI</ipxact:name>
          <ipxact:addressOffset>'h1c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>DST_ADDR_HI</ipxact:name>
            <ipxact:description>Upper 32 bits of the physical or virtual address of memory location within SoC memory address map or physical address within OT non-secure memory space.
Must be aligned to the transfer width.
Source and destination address must have the same alignment.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ADDR_SPACE_ID</ipxact:name>
          <ipxact:addressOffset>'h20</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SRC_ASID</ipxact:name>
            <ipxact:description>Target address space that the source address pointer refers to.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h7</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>DST_ASID</ipxact:name>
            <ipxact:description>Target address space that the destination address pointer refers to.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h7</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ENABLED_MEMORY_RANGE_BASE</ipxact:name>
          <ipxact:addressOffset>'h24</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>BASE</ipxact:name>
            <ipxact:description>Base Address to mark the start of the DMA enabled memory range within the OT internal memory space.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ENABLED_MEMORY_RANGE_LIMIT</ipxact:name>
          <ipxact:addressOffset>'h28</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>LIMIT</ipxact:name>
            <ipxact:description>Limit Address to mark the end of the DMA enabled memory range within the OT internal memory space; inclusive.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>RANGE_VALID</ipxact:name>
          <ipxact:addressOffset>'h2c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>RANGE_VALID</ipxact:name>
            <ipxact:description>Once set the enabled memory base and limit registers are valid.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>RANGE_REGWEN</ipxact:name>
          <ipxact:addressOffset>'h30</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>REGWEN</ipxact:name>
            <ipxact:description>Used by firmware to lock the DMA enabled memory range configuration registers from further modification.
The range registers are writable only while this field reads kMultiBitBool4True (0x6), its reset value.
A write from the reset value stores the written value, so writing kMultiBitBool4False (0x9) reads back 0x9, and any value other than 0x6 locks the range.
After that, writes can only clear bits 1 and 2 and set bits 0 and 3, so the field cannot return to kMultiBitBool4True before a reset.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h6</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:enumeratedValues>
              <ipxact:enumeratedValue>
                <ipxact:name>True</ipxact:name>
                <ipxact:value>'h6</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>False</ipxact:name>
                <ipxact:value>'h9</ipxact:value>
              </ipxact:enumeratedValue>
            </ipxact:enumeratedValues>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CFG_REGWEN</ipxact:name>
          <ipxact:addressOffset>'h34</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>REGWEN</ipxact:name>
            <ipxact:description>Used by hardware to lock the DMA configuration registers.
This register is purely managed by hardware and only software readable.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h6</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
            <ipxact:enumeratedValues>
              <ipxact:enumeratedValue>
                <ipxact:name>True</ipxact:name>
                <ipxact:value>'h6</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>False</ipxact:name>
                <ipxact:value>'h9</ipxact:value>
              </ipxact:enumeratedValue>
            </ipxact:enumeratedValues>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>TOTAL_DATA_SIZE</ipxact:name>
          <ipxact:addressOffset>'h38</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>DATA_SIZE</ipxact:name>
            <ipxact:description>Total size (in bytes) of the data to be transferred. The complete transfer operation
may consist of multiple chunks of data as specified by the CHUNK_DATA_SIZE register.

Minimum: 1 byte.
Maximum: May be restricted to a maximum pre-defined size based on OT DMA enabled memory space allocation.
Works in conjunction with the TRANSFER_WIDTH register.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CHUNK_DATA_SIZE</ipxact:name>
          <ipxact:addressOffset>'h3c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>DATA_SIZE</ipxact:name>
            <ipxact:description>Size (in bytes) for a single DMA transfer.
In hardware handshake mode, the DMA reads in chunks of CHUNK_DATA_SIZE from the peripheral.
For a single memory transfer CHUNK_DATA_SIZE and TOTAL_DATA_SIZE are set to the same value.

Minimum: 1 byte.
Maximum: May be restricted to a maximum pre-defined size based on OT DMA enabled memory space allocation.
Works in conjunction with the TRANSFER_WIDTH register.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>TRANSFER_WIDTH</ipxact:name>
          <ipxact:addressOffset>'h40</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>TRANSACTION_WIDTH</ipxact:name>
            <ipxact:description>Denotes the width of each transaction that the DMA shall issue during the data movement.

Multiple transactions of this width will be issued until TOTAL_DATA_SIZE bytes have been transferred.
Note that firmware may need to set a different value if a receiving IP supports a read / write transaction width that is less than 1 DWORD.
This does not affect the wrap-around mechanism.
Note that the value 3 for this register represents an invalid configuration that leads to an error.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h2</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>2</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CONTROL</ipxact:name>
          <ipxact:addressOffset>'h44</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>OPCODE</ipxact:name>
            <ipxact:description>Defines the type of DMA operations.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>HARDWARE_HANDSHAKE_ENABLE</ipxact:name>
            <ipxact:description>Enable hardware handshake mode.
Used to clear FIFOs from low speed IO peripherals receiving data, e.g., I3C receive buffer.
  Listen to an input trigger signal.
  Read data from source address location.
  Copy to destination address.
  Number of bytes specified in size register.
  Note assumption is the peripheral lowers input once FIFO is cleared.
No explicit clearing necessary.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>DIGEST_SWAP</ipxact:name>
            <ipxact:description>Digest register byte swap.

If 1 the value in each digest output register is converted to big-endian byte order.
This setting does not affect the order of the digest output registers, !!SHA2_DIGEST_0 still contains the first 4 bytes of the digest.</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>INITIAL_TRANSFER</ipxact:name>
            <ipxact:description>Marks the initial transfer to initialize the DMA and SHA engine for one transfer that can span over multiple single DMA transfers.
Used for hardware handshake and ordinary transfers, in which multiple transfers contribute to a final digest.
Note, for non-handshake transfers with inline hashing mode enabled, this bit must be set to also mark the first transfer.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ABORT</ipxact:name>
            <ipxact:description>Aborts the DMA operation if this bit is set.
Sets the corresponding bit in the status register once abort operation is complete.
Any OpenTitan-internal transactions are guaranteed to complete, but there are no guarantees on the SoC interface.</ipxact:description>
            <ipxact:bitOffset>27</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>GO</ipxact:name>
            <ipxact:description>Setting this bit triggers the DMA operation.
For normal operation, the DMA engine clears the `go` bit automatically after the configured operation is complete.
For hardware handshake operation, the DMA engine keeps the `go` bit set across chunks and clears it, setting `status.done`, once `total_data_size` bytes have been transferred.
Firmware clears the `go` bit to stop the hardware handshake operation earlier.</ipxact:description>
            <ipxact:bitOffset>31</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SRC_CONFIG</ipxact:name>
          <ipxact:addressOffset>'h48</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>INCREMENT</ipxact:name>
            <ipxact:description>Defines the address step within a chunk.
When 0: every read of a chunk uses the chunk's start address.
When 1: each read is transfer_width bytes above the previous one.
WRAP sets where the next chunk starts.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>WRAP</ipxact:name>
            <ipxact:description>When 0: each chunk starts where the previous one ended: with INCREMENT = 0, SRC_ADDR_LO/HI advance by CHUNK_DATA_SIZE after each chunk; with INCREMENT = 1, reads continue ascending from the end of the previous chunk.
When 1: every chunk starts at SRC_ADDR_LO/HI.
Set INCREMENT = 0 and WRAP = 1 to read every chunk from one fixed address, such as a peripheral FIFO.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>DST_CONFIG</ipxact:name>
          <ipxact:addressOffset>'h4c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>INCREMENT</ipxact:name>
            <ipxact:description>Defines the address step within a chunk.
When 0: every write of a chunk uses the chunk's start address.
When 1: each write is transfer_width bytes above the previous one.
WRAP sets where the next chunk starts.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>WRAP</ipxact:name>
            <ipxact:description>When 0: each chunk starts where the previous one ended: with INCREMENT = 0, DST_ADDR_LO/HI advance by CHUNK_DATA_SIZE after each chunk; with INCREMENT = 1, writes continue ascending from the end of the previous chunk.
When 1: every chunk starts at DST_ADDR_LO/HI.
Set INCREMENT = 0 and WRAP = 1 to write every chunk to one fixed address, such as a peripheral FIFO.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>STATUS</ipxact:name>
          <ipxact:addressOffset>'h50</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>BUSY</ipxact:name>
            <ipxact:description>DMA operation is active if this bit is set.
DMA engine clears this bit when operation is complete.
This bit may be set as long as hardware handshake mode is active and triggered.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>DONE</ipxact:name>
            <ipxact:description>Configured DMA operation is complete.
Cleared automatically by the hardware when starting a new transfer.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ABORTED</ipxact:name>
            <ipxact:description>Set once aborted operation drains.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ERROR</ipxact:name>
            <ipxact:description>Error occurred during the operation.
ERROR_CODE register denotes the source of the error.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SHA2_DIGEST_VALID</ipxact:name>
            <ipxact:description>Indicates whether the SHA2_DIGEST register contains a valid digest.
This value is cleared on the initial transfer and set when the digest is written.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CHUNK_DONE</ipxact:name>
            <ipxact:description>Transfer of a single chunk is complete.
Only raised for multi-chunk memory-to-memory transfers.
Cleared automatically by the hardware when starting the transfer of a new chunk.</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ERROR_CODE</ipxact:name>
          <ipxact:addressOffset>'h54</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SRC_ADDR_ERROR</ipxact:name>
            <ipxact:description>Source address is invalid.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>DST_ADDR_ERROR</ipxact:name>
            <ipxact:description>Destination address is invalid.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>OPCODE_ERROR</ipxact:name>
            <ipxact:description>Opcode is invalid.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SIZE_ERROR</ipxact:name>
            <ipxact:description>TRANSFER_WIDTH encodes an invalid value, TOTAL_DATA_SIZE or CHUNK_SIZE are zero, or inline hashing is not using 32-bit transfer width</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>BUS_ERROR</ipxact:name>
            <ipxact:description>The bus transfer returned an error.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>BASE_LIMIT_ERROR</ipxact:name>
            <ipxact:description>The base and limit addresses contain an invalid value.</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>RANGE_VALID_ERROR</ipxact:name>
            <ipxact:description>The DMA enabled memory range is not configured.</ipxact:description>
            <ipxact:bitOffset>6</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ASID_ERROR</ipxact:name>
            <ipxact:description>The source or destination ASID contains an invalid value.</ipxact:description>
            <ipxact:bitOffset>7</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SHA2_DIGEST_0</ipxact:name>
          <ipxact:dim>16</ipxact:dim>
          <ipxact:addressOffset>'h58</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>DATA_0</ipxact:name>
            <ipxact:description>SHA2 digest data</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>HANDSHAKE_INTR_ENABLE</ipxact:name>
          <ipxact:addressOffset>'h98</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>MASK</ipxact:name>
            <ipxact:description>Enable bits for incoming handshake interrupt wires.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h7ff</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>11</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CLEAR_INTR_SRC</ipxact:name>
          <ipxact:addressOffset>'h9c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SOURCE</ipxact:name>
            <ipxact:description>Source N needs interrupt cleared</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>11</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CLEAR_INTR_BUS</ipxact:name>
          <ipxact:addressOffset>'ha0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>BUS</ipxact:name>
            <ipxact:description>Bus selection bit for source N.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>11</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_SRC_ADDR_0</ipxact:name>
          <ipxact:dim>11</ipxact:dim>
          <ipxact:addressOffset>'ha4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>ADDR_0</ipxact:name>
            <ipxact:description>Destination address for interrupt source clearing write.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_SRC_WR_VAL_0</ipxact:name>
          <ipxact:dim>11</ipxact:dim>
          <ipxact:addressOffset>'h124</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>WR_VAL_0</ipxact:name>
            <ipxact:description>Write value for interrupt clearing write.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>wdt_timer</ipxact:name>
        <ipxact:displayName>Always-On Timer</ipxact:displayName>
        <ipxact:description>Wakeup and watchdog timers running on a low-power, always-on clock</ipxact:description>
        <ipxact:baseAddress>'h10801000</ipxact:baseAddress>
        <ipxact:range>'h38</ipxact:range>
        <ipxact:width>32</ipxact:width>
        <ipxact:register>
          <ipxact:name>ALERT_TEST</ipxact:name>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>fatal_fault</ipxact:name>
            <ipxact:description>Write 1 to trigger one alert event of this kind.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>WKUP_CTRL</ipxact:name>
          <ipxact:addressOffset>'h4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>enable</ipxact:name>
            <ipxact:description>When set to 1, the wakeup timer will count</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>prescaler</ipxact:name>
            <ipxact:description>Pre-scaler value for wakeup timer count</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>12</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>WKUP_THOLD_HI</ipxact:name>
          <ipxact:addressOffset>'h8</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>threshold_hi</ipxact:name>
            <ipxact:description>The count at which a wakeup interrupt should be generated, top 32 bits.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>WKUP_THOLD_LO</ipxact:name>
          <ipxact:addressOffset>'hc</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>threshold_lo</ipxact:name>
            <ipxact:description>The count at which a wakeup interrupt should be generated, bottom 32 bits.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>WKUP_COUNT_HI</ipxact:name>
          <ipxact:addressOffset>'h10</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>count_hi</ipxact:name>
            <ipxact:description>The current wakeup counter value, top 32 bits.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>WKUP_COUNT_LO</ipxact:name>
          <ipxact:addressOffset>'h14</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>count_lo</ipxact:name>
            <ipxact:description>The current wakeup counter value, bottom 32 bits.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>WDOG_REGWEN</ipxact:name>
          <ipxact:addressOffset>'h18</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>regwen</ipxact:name>
            <ipxact:description>Once cleared, the watchdog configuration will be locked until the next reset.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>WDOG_CTRL</ipxact:name>
          <ipxact:addressOffset>'h1c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>enable</ipxact:name>
            <ipxact:description>When set to 1, the watchdog timer will count.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>pause_in_sleep</ipxact:name>
            <ipxact:description>When set to 1, the watchdog timer will not count during sleep.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>WDOG_BARK_THOLD</ipxact:name>
          <ipxact:addressOffset>'h20</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>threshold</ipxact:name>
            <ipxact:description>The count at which a watchdog bark interrupt should be generated.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>WDOG_BITE_THOLD</ipxact:name>
          <ipxact:addressOffset>'h24</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>threshold</ipxact:name>
            <ipxact:description>The count at which a watchdog bite reset should be generated.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>WDOG_COUNT</ipxact:name>
          <ipxact:addressOffset>'h28</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>count</ipxact:name>
            <ipxact:description>The current watchdog counter value.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_STATE</ipxact:name>
          <ipxact:addressOffset>'h2c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>wkup_timer_expired</ipxact:name>
            <ipxact:description>Raised if the wakeup timer has hit the specified threshold.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>wdog_timer_bark</ipxact:name>
            <ipxact:description>Raised if the watchdog timer has hit the bark threshold.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_TEST</ipxact:name>
          <ipxact:addressOffset>'h30</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>wkup_timer_expired</ipxact:name>
            <ipxact:description>Write 1 to force wkup_timer_expired interrupt.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>wdog_timer_bark</ipxact:name>
            <ipxact:description>Write 1 to force wdog_timer_bark interrupt.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>WKUP_CAUSE</ipxact:name>
          <ipxact:addressOffset>'h34</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>cause</ipxact:name>
            <ipxact:description>AON timer requested wakeup, write 0 to clear.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>sep_scratch_cold</ipxact:name>
        <ipxact:displayName>SEP Scratch Address Map</ipxact:displayName>
        <ipxact:description>General-purpose SEP scratch register bank.</ipxact:description>
        <ipxact:baseAddress>'h10802000</ipxact:baseAddress>
        <ipxact:range>'h40</ipxact:range>
        <ipxact:width>64</ipxact:width>
        <ipxact:register>
          <ipxact:name>SCRATCH</ipxact:name>
          <ipxact:dim>8</ipxact:dim>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>data</ipxact:name>
            <ipxact:description>Scratch register for the CPU</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>sep_scratch_warm</ipxact:name>
        <ipxact:displayName>SEP Scratch Address Map</ipxact:displayName>
        <ipxact:description>General-purpose SEP scratch register bank.</ipxact:description>
        <ipxact:baseAddress>'h10802080</ipxact:baseAddress>
        <ipxact:range>'h40</ipxact:range>
        <ipxact:width>64</ipxact:width>
        <ipxact:register>
          <ipxact:name>SCRATCH</ipxact:name>
          <ipxact:dim>8</ipxact:dim>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>data</ipxact:name>
            <ipxact:description>Scratch register for the CPU</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>sep_reset_ctrl</ipxact:name>
        <ipxact:displayName>SEP Reset Control Address Map</ipxact:displayName>
        <ipxact:description>Software resets for KM, OTBN, AES, HMAC, KMAC, the internal TRNG, and Adams Bridge.</ipxact:description>
        <ipxact:baseAddress>'h10803000</ipxact:baseAddress>
        <ipxact:range>'h8</ipxact:range>
        <ipxact:width>64</ipxact:width>
        <ipxact:register>
          <ipxact:name>SW_RESET_N</ipxact:name>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>km_sw_rst_n</ipxact:name>
            <ipxact:description>KM reset (0=assert, 1=release)</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>otbn_sw_rst_n</ipxact:name>
            <ipxact:description>OTBN reset (0=assert, 1=release)</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>aes_sw_rst_n</ipxact:name>
            <ipxact:description>AES reset (0=assert, 1=release)</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>hmac_sw_rst_n</ipxact:name>
            <ipxact:description>HMAC reset (0=assert, 1=release)</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>kmac_sw_rst_n</ipxact:name>
            <ipxact:description>KMAC reset (0=assert, 1=release)</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>trng_sw_rst_n</ipxact:name>
            <ipxact:description>Internal TRNG reset request (0=assert, 1=release). Hardware drains and isolates the entropy-source, CSRNG, and EDN AXI ports before asserting the shared TRNG reset.</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>abr_sw_rst_n</ipxact:name>
            <ipxact:description>Adams Bridge reset (0=assert, 1=release)</ipxact:description>
            <ipxact:bitOffset>6</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>otbn</ipxact:name>
        <ipxact:displayName>OpenTitan Big Number Accelerator</ipxact:displayName>
        <ipxact:description>Programmable coprocessor for asymmetric cryptography with SCA and FI countermeasures</ipxact:description>
        <ipxact:baseAddress>'h10900000</ipxact:baseAddress>
        <ipxact:range>'hc000</ipxact:range>
        <ipxact:width>32</ipxact:width>
        <ipxact:register>
          <ipxact:name>INTR_STATE</ipxact:name>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>done</ipxact:name>
            <ipxact:description>OTBN has completed the operation.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_ENABLE</ipxact:name>
          <ipxact:addressOffset>'h4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>done</ipxact:name>
            <ipxact:description>Enable interrupt when !!INTR_STATE.done is set.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_TEST</ipxact:name>
          <ipxact:addressOffset>'h8</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>done</ipxact:name>
            <ipxact:description>Write 1 to force !!INTR_STATE.done to 1.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ALERT_TEST</ipxact:name>
          <ipxact:addressOffset>'hc</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>fatal</ipxact:name>
            <ipxact:description>Write 1 to trigger one alert event of this kind.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>recov</ipxact:name>
            <ipxact:description>Write 1 to trigger one alert event of this kind.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CMD</ipxact:name>
          <ipxact:addressOffset>'h10</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>cmd</ipxact:name>
            <ipxact:description>The operation to perform.

| Value | Name          | Description |
|:------|:--------------|:------------|
| 0xd8  | EXECUTE       | Starts the execution of the program stored in the instruction memory, starting at address zero. |
| 0xc3  | SEC_WIPE_DMEM | Securely removes all contents from the data memory. |
| 0x1e  | SEC_WIPE_IMEM | Securely removes all contents from the instruction  memory. |</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CTRL</ipxact:name>
          <ipxact:addressOffset>'h14</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>software_errs_fatal</ipxact:name>
            <ipxact:description>Controls the reaction to software errors.

When set software errors produce fatal errors, rather than
recoverable errors.

Writes are ignored if OTBN is not idle.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>STATUS</ipxact:name>
          <ipxact:addressOffset>'h18</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>status</ipxact:name>
            <ipxact:description>Indicates the current operational state OTBN is in.

All BUSY values represent an operation started by a write to the
!!CMD register.

| Value | Name               | Description                                           |
|:------|:-------------------|:------------------------------------------------------|
| 0x00  | IDLE               | OTBN is idle: it is not performing any action.        |
| 0x01  | BUSY_EXECUTE       | OTBN is busy executing software.                      |
| 0x02  | BUSY_SEC_WIPE_DMEM | OTBN is busy securely wiping the data memory.         |
| 0x03  | BUSY_SEC_WIPE_IMEM | OTBN is busy securely wiping the instruction memory.  |
| 0x04  | BUSY_SEC_WIPE_INT  | OTBN is busy securely wiping the internal state.      |
| 0xFF  | LOCKED             | OTBN is locked as reaction to a fatal error, and must be reset to unlock it again. See also the section &quot;Reaction to Fatal Errors&quot;. |</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h4</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ERR_BITS</ipxact:name>
          <ipxact:addressOffset>'h1c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>bad_data_addr</ipxact:name>
            <ipxact:description>A `BAD_DATA_ADDR` error was observed.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>bad_insn_addr</ipxact:name>
            <ipxact:description>A `BAD_INSN_ADDR` error was observed.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>call_stack</ipxact:name>
            <ipxact:description>A `CALL_STACK` error was observed.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>illegal_insn</ipxact:name>
            <ipxact:description>An `ILLEGAL_INSN` error was observed.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>loop</ipxact:name>
            <ipxact:description>A `LOOP` error was observed.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>key_invalid</ipxact:name>
            <ipxact:description>A `KEY_INVALID` error was observed.</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rnd_rep_chk_fail</ipxact:name>
            <ipxact:description>An `RND_REP_CHK_FAIL` error was observed.</ipxact:description>
            <ipxact:bitOffset>6</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rnd_fips_chk_fail</ipxact:name>
            <ipxact:description>An `RND_FIPS_CHK_FAIL` error was observed.</ipxact:description>
            <ipxact:bitOffset>7</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>mai_software_error</ipxact:name>
            <ipxact:description>An `MAI_SOFTWARE_ERROR` error was observed.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>imem_intg_violation</ipxact:name>
            <ipxact:description>A `IMEM_INTG_VIOLATION` error was observed.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>dmem_intg_violation</ipxact:name>
            <ipxact:description>A `DMEM_INTG_VIOLATION` error was observed.</ipxact:description>
            <ipxact:bitOffset>17</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>reg_intg_violation</ipxact:name>
            <ipxact:description>A `REG_INTG_VIOLATION` error was observed.</ipxact:description>
            <ipxact:bitOffset>18</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>bus_intg_violation</ipxact:name>
            <ipxact:description>A `BUS_INTG_VIOLATION` error was observed.</ipxact:description>
            <ipxact:bitOffset>19</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>bad_internal_state</ipxact:name>
            <ipxact:description>A `BAD_INTERNAL_STATE` error was observed.</ipxact:description>
            <ipxact:bitOffset>20</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>illegal_bus_access</ipxact:name>
            <ipxact:description>An `ILLEGAL_BUS_ACCESS` error was observed.</ipxact:description>
            <ipxact:bitOffset>21</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>lifecycle_escalation</ipxact:name>
            <ipxact:description>A `LIFECYCLE_ESCALATION` error was observed.</ipxact:description>
            <ipxact:bitOffset>22</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fatal_software</ipxact:name>
            <ipxact:description>A `FATAL_SOFTWARE` error was observed.</ipxact:description>
            <ipxact:bitOffset>23</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>FATAL_ALERT_CAUSE</ipxact:name>
          <ipxact:addressOffset>'h20</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>imem_intg_violation</ipxact:name>
            <ipxact:description>A `IMEM_INTG_VIOLATION` error was observed.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>dmem_intg_violation</ipxact:name>
            <ipxact:description>A `DMEM_INTG_VIOLATION` error was observed.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>reg_intg_violation</ipxact:name>
            <ipxact:description>A `REG_INTG_VIOLATION` error was observed.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>bus_intg_violation</ipxact:name>
            <ipxact:description>A `BUS_INTG_VIOLATION` error was observed.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>bad_internal_state</ipxact:name>
            <ipxact:description>A `BAD_INTERNAL_STATE` error was observed.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>illegal_bus_access</ipxact:name>
            <ipxact:description>A `ILLEGAL_BUS_ACCESS` error was observed.</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>lifecycle_escalation</ipxact:name>
            <ipxact:description>A `LIFECYCLE_ESCALATION` error was observed.</ipxact:description>
            <ipxact:bitOffset>6</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fatal_software</ipxact:name>
            <ipxact:description>A `FATAL_SOFTWARE` error was observed.</ipxact:description>
            <ipxact:bitOffset>7</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INSN_CNT</ipxact:name>
          <ipxact:addressOffset>'h24</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>insn_cnt</ipxact:name>
            <ipxact:description>The number of executed instructions.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>LOAD_CHECKSUM</ipxact:name>
          <ipxact:addressOffset>'h28</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>checksum</ipxact:name>
            <ipxact:description>Checksum accumulator</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>aes</ipxact:name>
        <ipxact:displayName>AES Accelerator</ipxact:displayName>
        <ipxact:description>AES encryption and decryption engine with SCA and FI countermeasures</ipxact:description>
        <ipxact:baseAddress>'h10910000</ipxact:baseAddress>
        <ipxact:range>'h8c</ipxact:range>
        <ipxact:width>32</ipxact:width>
        <ipxact:register>
          <ipxact:name>ALERT_TEST</ipxact:name>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>RECOV_CTRL_UPDATE_ERR</ipxact:name>
            <ipxact:description>Write 1 to trigger one alert event of this kind.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FATAL_FAULT</ipxact:name>
            <ipxact:description>Write 1 to trigger one alert event of this kind.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>KEY_SHARE0</ipxact:name>
          <ipxact:dim>8</ipxact:dim>
          <ipxact:addressOffset>'h4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>KEY_SHARE0</ipxact:name>
            <ipxact:description>Initial Key Share 0</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>KEY_SHARE1</ipxact:name>
          <ipxact:dim>8</ipxact:dim>
          <ipxact:addressOffset>'h24</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>KEY_SHARE1</ipxact:name>
            <ipxact:description>Initial Key Share 1</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>IV</ipxact:name>
          <ipxact:dim>4</ipxact:dim>
          <ipxact:addressOffset>'h44</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>IV</ipxact:name>
            <ipxact:description>Initialization Vector</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>DATA_IN</ipxact:name>
          <ipxact:dim>4</ipxact:dim>
          <ipxact:addressOffset>'h54</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>DATA_IN</ipxact:name>
            <ipxact:description>Input Data</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>DATA_OUT</ipxact:name>
          <ipxact:dim>4</ipxact:dim>
          <ipxact:addressOffset>'h64</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>DATA_OUT</ipxact:name>
            <ipxact:description>Output Data</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CTRL_SHADOWED</ipxact:name>
          <ipxact:addressOffset>'h74</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>OPERATION</ipxact:name>
            <ipxact:description>2-bit one-hot field to select the operation of AES unit.
Invalid input values, i.e., values with multiple bits set and value 2'b00, are mapped to AES_ENC (2'b01).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>2</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>MODE</ipxact:name>
            <ipxact:description>6-bit one-hot field to select AES block cipher mode.
Invalid input values, i.e., values with multiple bits set and value 6'b00_0000, are mapped to AES_NONE (6'b11_1111).</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h3f</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>6</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>KEY_LEN</ipxact:name>
            <ipxact:description>3-bit one-hot field to select AES key length.
Invalid input values, i.e., values with multiple bits set, value 3'b000, and value 3'b010 in case 192-bit keys are not supported (because disabled at compile time) are mapped to AES_256 (3'b100).</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>3</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SIDELOAD</ipxact:name>
            <ipxact:description>Controls whether the AES unit uses the key provided by the key manager via key sideload interface (1) or the key provided by software via Initial Key Registers KEY_SHARE1_0 - KEY_SHARE1_7 (0).</ipxact:description>
            <ipxact:bitOffset>11</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>PRNG_RESEED_RATE</ipxact:name>
            <ipxact:description>3-bit one-hot field to control the reseeding rate of the internal pseudo-random number generator (PRNG) used for masking.
Invalid input values, i.e., values with multiple bits set and value 3'b000 are mapped to the highest reseeding rate PER_1 (3'b001).</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>3</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>MANUAL_OPERATION</ipxact:name>
            <ipxact:description>Controls whether the AES unit is operated in normal/automatic mode (0) or fully manual mode (1).
In automatic mode (0), the AES unit automatically i) starts to encrypt/decrypt when it receives new input data, and ii) stalls during the last encryption/decryption cycle if the previous output data has not yet been read.
This is the most efficient mode to operate in.
Note that the corresponding status tracking is automatically cleared upon a write to the Control Register.
In manual mode (1), the AES unit i) only starts to encrypt/decrypt after receiving a start trigger (see Trigger Register), and ii) overwrites previous output data irrespective of whether it has been read out or not.
This mode is useful if software needs full control over the AES unit.</ipxact:description>
            <ipxact:bitOffset>15</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CTRL_AUX_SHADOWED</ipxact:name>
          <ipxact:addressOffset>'h78</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>KEY_TOUCH_FORCES_RESEED</ipxact:name>
            <ipxact:description>Controls whether providing a new key triggers the reseeding of internal pseudo-random number generators used for clearing and masking (1) or not (0).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FORCE_MASKS</ipxact:name>
            <ipxact:description>Allow the internal masking PRNG to advance (0) or force its internal state (1) leading to constant masks.
Setting all masks to constant value can be useful when performing SCA.
To completely disable the masking, the second key share (KEY_SHARE1_0 - KEY_SHARE1_7) must be zero as well.
In addition, a special seed needs to be loaded into the masking PRNG using the EDN interface.
Only applicable if both the Masking parameter and the SecAllowForcingMasks parameter are set to one.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CTRL_AUX_REGWEN</ipxact:name>
          <ipxact:addressOffset>'h7c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>CTRL_AUX_REGWEN</ipxact:name>
            <ipxact:description>Auxiliary Control Register configuration enable bit.
If this is cleared to 0, the Auxiliary Control Register cannot be written anymore.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>TRIGGER</ipxact:name>
          <ipxact:addressOffset>'h80</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>START</ipxact:name>
            <ipxact:description>Keep AES unit paused (0) or trigger the encryption/decryption of one data block (1).
This trigger is cleared to `0` if MANUAL_OPERATION=0 or if MODE=AES_NONE (see Control Register).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>KEY_IV_DATA_IN_CLEAR</ipxact:name>
            <ipxact:description>Keep current values in Initial Key, internal Full Key and Decryption Key registers, IV registers and Input Data registers (0) or clear all those registers with pseudo-random data (1).</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>DATA_OUT_CLEAR</ipxact:name>
            <ipxact:description>Keep current values in Output Data registers (0) or clear those registers with pseudo-random data (1).</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>PRNG_RESEED</ipxact:name>
            <ipxact:description>Keep continuing with the current states of the internal pseudo-random number generators used for register clearing and masking (0) or perform a reseed of the internal states from the connected entropy source (1).
If the KEY_TOUCH_FORCES_RESEED bit in the Auxiliary Control Register is set to one, this trigger will automatically get set after providing a new initial key.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>STATUS</ipxact:name>
          <ipxact:addressOffset>'h84</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>IDLE</ipxact:name>
            <ipxact:description>The AES unit is idle (1) or busy (0).
This flag is `0` if one of the following operations is currently running: i) encryption/decryption, ii) register clearing or iii) PRNG reseeding.
This flag is also `0` if an encryption/decryption is running but the AES unit is stalled.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>STALL</ipxact:name>
            <ipxact:description>The AES unit is not stalled (0) or stalled (1) because there is previous
output data that must be read by the processor before the AES unit can
overwrite this data.
This flag is not meaningful if MANUAL_OPERATION=1 (see Control Register).</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>OUTPUT_LOST</ipxact:name>
            <ipxact:description>All previous output data has been fully read by the processor (0) or at least one previous output data block has been lost (1).
It has been overwritten by the AES unit before the processor could fully read it.
Once set to `1`, this flag remains set until AES operation is restarted by re-writing the Control Register.
The primary use of this flag is for design verification.
This flag is not meaningful if MANUAL_OPERATION=0 (see Control Register).</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>OUTPUT_VALID</ipxact:name>
            <ipxact:description>The AES unit has no valid output (0) or has valid output data (1).</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>INPUT_READY</ipxact:name>
            <ipxact:description>The AES unit is ready (1) or not ready (0) to receive new data input via the DATA_IN registers.
If the present values in the DATA_IN registers have not yet been loaded into the
module this flag is `0` (not ready).</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ALERT_RECOV_CTRL_UPDATE_ERR</ipxact:name>
            <ipxact:description>An update error has not occurred (0) or has occurred (1) in the shadowed Control Register.
AES operation needs to be restarted by re-writing the Control Register.</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ALERT_FATAL_FAULT</ipxact:name>
            <ipxact:description>No fatal fault has occurred inside the AES unit (0).
A fatal fault has occurred and the AES unit needs to be reset (1).
Examples for fatal faults include
i) storage errors in the Control Register,
ii) if any internal FSM enters an invalid state,
iii) if any sparsely encoded signal takes on an invalid value,
iv) errors in the internal round counter,
v) escalations triggered by the life cycle controller, and
vi) fatal integrity failures on the TL-UL bus.</ipxact:description>
            <ipxact:bitOffset>6</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CTRL_GCM_SHADOWED</ipxact:name>
          <ipxact:addressOffset>'h88</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>PHASE</ipxact:name>
            <ipxact:description>6-bit one-hot field to select the phase of the Galois/Counter Mode (GCM) of operation.
Invalid input values, i.e., values with multiple bits set and value 6'b00_0000, are mapped to GCM_INIT (6'b00_0001).
In case support for GCM has been disabled at compile time, this field is not writable and always reads as GCM_INIT (6'b00_0001).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>6</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>NUM_VALID_BYTES</ipxact:name>
            <ipxact:description>Number of valid bytes of the current input block.
Only the last block in the GCM_AAD and GCM_TEXT phases are expected to have not all bytes marked as valid.
For all other blocks, the number of valid bytes should be set to 16.
Invalid input values, i.e., the value 5'b0_0000, and all other values different from 5'b1_0000 in case GCM is not supported (because disabled at compile time) are mapped to 5'b1_0000.</ipxact:description>
            <ipxact:bitOffset>6</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h10</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>hmac</ipxact:name>
        <ipxact:displayName>HMAC Accelerator</ipxact:displayName>
        <ipxact:description>Accelerator for SHA-2 256/384/512-based keyed HMAC and the hash function</ipxact:description>
        <ipxact:baseAddress>'h10911000</ipxact:baseAddress>
        <ipxact:range>'h2000</ipxact:range>
        <ipxact:width>32</ipxact:width>
        <ipxact:register>
          <ipxact:name>INTR_STATE</ipxact:name>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>hmac_done</ipxact:name>
            <ipxact:description>HMAC/SHA-2 has completed.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fifo_empty</ipxact:name>
            <ipxact:description>The message FIFO is empty.
This interrupt is raised only if the message FIFO is actually writable by software, i.e., if all of the following conditions are met:
i) The HMAC block is not running in HMAC mode and performing the second round of computing the final hash of the outer key as well as the result of the first round using the inner key.
ii) Software has not yet written the Process or Stop command to finish the hashing operation.
For the interrupt to be raised, the message FIFO must also have been full previously.
Otherwise, the hardware empties the FIFO faster than software can fill it and there is no point in interrupting the software to inform it about the message FIFO being empty.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>hmac_err</ipxact:name>
            <ipxact:description>HMAC error has occurred. ERR_CODE register shows which error occurred.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_ENABLE</ipxact:name>
          <ipxact:addressOffset>'h4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>hmac_done</ipxact:name>
            <ipxact:description>Enable interrupt when !!INTR_STATE.hmac_done is set.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fifo_empty</ipxact:name>
            <ipxact:description>Enable interrupt when !!INTR_STATE.fifo_empty is set.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>hmac_err</ipxact:name>
            <ipxact:description>Enable interrupt when !!INTR_STATE.hmac_err is set.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_TEST</ipxact:name>
          <ipxact:addressOffset>'h8</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>hmac_done</ipxact:name>
            <ipxact:description>Write 1 to force !!INTR_STATE.hmac_done to 1.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fifo_empty</ipxact:name>
            <ipxact:description>Write 1 to force !!INTR_STATE.fifo_empty to 1.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>hmac_err</ipxact:name>
            <ipxact:description>Write 1 to force !!INTR_STATE.hmac_err to 1.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ALERT_TEST</ipxact:name>
          <ipxact:addressOffset>'hc</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>fatal_fault</ipxact:name>
            <ipxact:description>Write 1 to trigger one alert event of this kind.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CFG</ipxact:name>
          <ipxact:addressOffset>'h10</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>hmac_en</ipxact:name>
            <ipxact:description>HMAC datapath enable.

If this bit is 1, HMAC operates when `hash_start` toggles.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>sha_en</ipxact:name>
            <ipxact:description>SHA-2 enable.

If 0, the SHA engine will not initiate compression, this is used to stop operation of the SHA-2 engine until configuration has been done.
When the SHA-2 engine is disabled the digest is cleared.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>endian_swap</ipxact:name>
            <ipxact:description>Endian swap.

If 0, each value will be added to the message in little-endian byte order.
The value is written to MSG_FIFO same to the SW writes.
If 1, then each individual multi-byte value, regardless of its alignment, written to !!MSG_FIFO will be added to the message in big-endian byte order.
A message written to !!MSG_FIFO one byte at a time will not be affected by this setting.
From a hardware perspective byte swaps are performed on a TL-UL word granularity.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>digest_swap</ipxact:name>
            <ipxact:description>Digest register byte swap.

If 1 the value in each digest output register is converted to big-endian byte order.
This setting does not affect the order of the digest output registers, !!DIGEST_0 still contains the first 4 bytes of the digest.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>key_swap</ipxact:name>
            <ipxact:description>Key register byte swap (deprecated: KEY path is for DV only; production uses key manager sideload).

If 1 the endianness of each KEY_* register is swapped. Default value (value 0) is big endian representation of the KEY_* CSRs.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>digest_size</ipxact:name>
            <ipxact:description>Digest size configuration.

This is a 4-bit one-hot encoded field to select digest size for either HMAC or SHA-2.
Invalid/unsupported values, i.e., values that don't correspond to SHA2_256, SHA2_384, or SHA2_512, are mapped to SHA2_None.</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h8</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>key_length</ipxact:name>
            <ipxact:description>Key length configuration.

This is a 6-bit one-hot encoded field to configure the key length for HMAC.

The HMAC can be programmed with the following key lengths: 128-bit, 256-bit, 384-bit, 512-bit and 1024-bit.
But the HMAC supports any arbitrary key length: the software should configure the HMAC with the next largest supported key length and concatenate zeros to reach the programmed key length.
The position of these zeros depends on the endianness, thus on the programmed [`CFG.key_swap`](registers.md#cfg--key_swap).
For example, for an 80-bit key, HMAC should be configured with an 128-bit key length, fed with the 80-bit key and with 48 zero-bits.

Note that the key length cannot be greater than the block size: up to 1024-bit for SHA-2 384/512 and up to 512-bit for SHA-2 256.
The value of this register is irrelevant when only SHA-2 (not keyed HMAC) is configured.
However, for HMAC mode (`hmac_en == 1`), when HMAC is triggered to start while !!KEY_LENGTH holds `Key_None` or !!KEY_LENGTH holds `Key_1024` for !!DIGEST_SIZE = `SHA2_256`, starting is blocked and an error is signalled to SW.</ipxact:description>
            <ipxact:bitOffset>9</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h20</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>6</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CMD</ipxact:name>
          <ipxact:addressOffset>'h14</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>hash_start</ipxact:name>
            <ipxact:description>If 1 is written into this field, SHA-2 or HMAC begins its operation.
CPU must configure relative information first, such as the digest size, secret key and the key length.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>hash_process</ipxact:name>
            <ipxact:description>If 1 is written to this field, SHA-2 or HMAC calculates the digest or signing based on currently received message.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>hash_stop</ipxact:name>
            <ipxact:description>When 1 is written to this field, SHA-2 or HMAC will afterwards set the `hmac_done` interrupt as soon as the current block has been hashed.
The hash can then be read from the registers !!DIGEST_0 to !!DIGEST_15.
Together with the message length in !!MSG_LENGTH_LOWER and !!MSG_LENGTH_UPPER, this forms the information that has to be saved before switching context.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>hash_continue</ipxact:name>
            <ipxact:description>When 1 is written to this field, SHA-2 or HMAC will continue hashing based on the current hash in the digest registers and the message length, which both have to be restored to switch context.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>STATUS</ipxact:name>
          <ipxact:addressOffset>'h18</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>hmac_idle</ipxact:name>
            <ipxact:description>HMAC idle status.
When IDLE, the `DIGEST` and the `MSG_LENGTH_LOWER`/`MSG_LENGTH_UPPER` can be written to from SW which enables restoring context (to support context switching).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fifo_empty</ipxact:name>
            <ipxact:description>FIFO empty</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fifo_full</ipxact:name>
            <ipxact:description>FIFO full. Data written to the FIFO whilst it is full will cause back-pressure on the interconnect</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fifo_depth</ipxact:name>
            <ipxact:description>FIFO entry count.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:bitWidth>6</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ERR_CODE</ipxact:name>
          <ipxact:addressOffset>'h1c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>err_code</ipxact:name>
            <ipxact:description>If an error interrupt occurs, this register has information of error cause.
Please take a look at `hw/ip/prim/rtl/prim_sha2_pkg.sv:err_code_e enum type.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>WIPE_SECRET</ipxact:name>
          <ipxact:addressOffset>'h20</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>secret</ipxact:name>
            <ipxact:description>Secret value</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>KEY</ipxact:name>
          <ipxact:dim>32</ipxact:dim>
          <ipxact:addressOffset>'h24</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>key_0</ipxact:name>
            <ipxact:description>32-bit chunk of 1024-bit secret key</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>DIGEST</ipxact:name>
          <ipxact:dim>16</ipxact:dim>
          <ipxact:addressOffset>'ha4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>digest_0</ipxact:name>
            <ipxact:description>32-bit chunk of 512-bit digest</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MSG_LENGTH_LOWER</ipxact:name>
          <ipxact:addressOffset>'he4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>v</ipxact:name>
            <ipxact:description>Message Length [31:0]</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MSG_LENGTH_UPPER</ipxact:name>
          <ipxact:addressOffset>'he8</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>v</ipxact:name>
            <ipxact:description>Message Length [63:32]</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>kmac</ipxact:name>
        <ipxact:displayName>KMAC Accelerator</ipxact:displayName>
        <ipxact:description>Accelerator for Keccak-based keyed hash message authentication code and SHA-3 hash functions; with SCA and FI countermeasures</ipxact:description>
        <ipxact:baseAddress>'h10913000</ipxact:baseAddress>
        <ipxact:range>'h1000</ipxact:range>
        <ipxact:width>32</ipxact:width>
        <ipxact:register>
          <ipxact:name>INTR_STATE</ipxact:name>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>kmac_done</ipxact:name>
            <ipxact:description>KMAC/SHA3 absorbing has been completed</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fifo_empty</ipxact:name>
            <ipxact:description>The message FIFO is empty.
This interrupt is raised only if the message FIFO is actually writable by software, i.e., if all of the following conditions are met:
i) The KMAC block is not exercised by a hardware application interface.
ii) The SHA3 block is in the Absorb state.
iii) Software has not yet written the Process command to finish the absorption process.
For the interrupt to be raised, the message FIFO must also have been full previously.
Otherwise, the hardware empties the FIFO faster than software can fill it and there is no point in interrupting the software to inform it about the message FIFO being empty.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>kmac_err</ipxact:name>
            <ipxact:description>KMAC/SHA3 error occurred. ERR_CODE register shows the details</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_ENABLE</ipxact:name>
          <ipxact:addressOffset>'h4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>kmac_done</ipxact:name>
            <ipxact:description>Enable interrupt when !!INTR_STATE.kmac_done is set.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fifo_empty</ipxact:name>
            <ipxact:description>Enable interrupt when !!INTR_STATE.fifo_empty is set.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>kmac_err</ipxact:name>
            <ipxact:description>Enable interrupt when !!INTR_STATE.kmac_err is set.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_TEST</ipxact:name>
          <ipxact:addressOffset>'h8</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>kmac_done</ipxact:name>
            <ipxact:description>Write 1 to force !!INTR_STATE.kmac_done to 1.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fifo_empty</ipxact:name>
            <ipxact:description>Write 1 to force !!INTR_STATE.fifo_empty to 1.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>kmac_err</ipxact:name>
            <ipxact:description>Write 1 to force !!INTR_STATE.kmac_err to 1.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ALERT_TEST</ipxact:name>
          <ipxact:addressOffset>'hc</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>recov_operation_err</ipxact:name>
            <ipxact:description>Write 1 to trigger one alert event of this kind.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fatal_fault_err</ipxact:name>
            <ipxact:description>Write 1 to trigger one alert event of this kind.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CFG_REGWEN</ipxact:name>
          <ipxact:addressOffset>'h10</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>en</ipxact:name>
            <ipxact:description>Configuration enable.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CFG_SHADOWED</ipxact:name>
          <ipxact:addressOffset>'h14</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>kmac_en</ipxact:name>
            <ipxact:description>KMAC datapath enable.

If this bit is 1, the KMAC mode is active and the secret key is prepended to the incoming message.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>kstrength</ipxact:name>
            <ipxact:description>Hashing Strength

3 bit field to select the security strength of SHA3 hashing
engine. If mode field is set to SHAKE or cSHAKE, only 128 and
256 strength can be selected. Other value will result error
when hashing starts.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>3</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>mode</ipxact:name>
            <ipxact:description>Keccak hashing mode.

This module supports SHA3 main hashing algorithm and the part
of its derived functions, SHAKE and cSHAKE with limitations.
This field is to select the mode.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>2</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>msg_endianness</ipxact:name>
            <ipxact:description>Message Endianness.

If 1 then each individual multi-byte value, regardless of its
alignment, written to !!MSG_FIFO will be added to the message
in big-endian byte order.
If 0, each value will be added to the message in little-endian
byte order.
A message written to !!MSG_FIFO one byte at a time will not be
affected by this setting.
From a hardware perspective byte swaps are performed on a TL-UL
word granularity.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>state_endianness</ipxact:name>
            <ipxact:description>State Endianness.

If 1 then each individual word in the !!STATE output register
is converted to big-endian byte order.
The order of the words in relation to one another is not
changed.
This setting does not affect how the state is interpreted
during computation.</ipxact:description>
            <ipxact:bitOffset>9</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>sideload</ipxact:name>
            <ipxact:description>Sideloaded Key. Deprecated: defaults to 1 (sideload). Set to 0 for DV testing with SW key path only.

If 1, KMAC uses KeyMgr sideloaded key for SW initiated KMAC
operation. KMAC uses the sideloaded key regardless of this
configuration when KeyMgr initiates the KMAC operation for
Key Derivation Function (KDF).</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>entropy_mode</ipxact:name>
            <ipxact:description>Entropy Mode

Using this field, software can configure mode of operation of the internal pseudo-random number generator (PRNG).

Note that once software has configured a value different from `idle_mode` after reset, and set the !!CFG_SHADOWED.entropy_ready bit afterwards, the PRNG configuration cannot be changed anymore (unless an EDN request timeout occurs when running in EDN mode).
Further writes to this field will change the value received upon reading the register, but they will be ignored by the internal hardware.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>2</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>entropy_fast_process</ipxact:name>
            <ipxact:description>Entropy Fast process mode.

If 1, entropy logic uses garbage data while not processing the KMAC
key block. It will re-use previous entropy value and will not
expand the entropy when it is consumed. Only it refreshes the
entropy while processing the secret key block. This process should
not be used if SCA resistance is required because it may cause side
channel leakage.</ipxact:description>
            <ipxact:bitOffset>19</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>msg_mask</ipxact:name>
            <ipxact:description>Message Masking with PRNG.

If 1, KMAC applies PRNG to the input messages to the Keccak module
when KMAC mode is on.</ipxact:description>
            <ipxact:bitOffset>20</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>entropy_ready</ipxact:name>
            <ipxact:description>Entropy Ready status.

Software sets this field to allow the entropy generator in KMAC to
fetch the entropy and run.</ipxact:description>
            <ipxact:bitOffset>24</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>en_unsupported_modestrength</ipxact:name>
            <ipxact:description>Enable Unsupported Mode and Strength configs.

SW may set this field for KMAC to move forward with unsupported
Keccak Mode and Strength configurations, such as cSHAKE512.

If not set, KMAC won't propagate the SW command (CmdStart) to the
rest of the blocks (AppIntf, KMAC Core, SHA3).</ipxact:description>
            <ipxact:bitOffset>26</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CMD</ipxact:name>
          <ipxact:addressOffset>'h18</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>cmd</ipxact:name>
            <ipxact:description>Issue a command to the KMAC/SHA3 IP. The command is sparse
encoded. To prevent sw from writing multiple commands at once,
the field is defined as enum.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>6</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>entropy_req</ipxact:name>
            <ipxact:description>Software can set this bit to 1 to manually trigger the reseeding of the internal PRNG when running in EDN mode.
This will also clear !!ENTROPY_REFRESH_HASH_CNT.

Note that the hardware may miss the trigger pulse if the module is not idle, or if the module is currently performing a reseed operation.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>hash_cnt_clr</ipxact:name>
            <ipxact:description>Software can set this bit to 1 to manually clear !!ENTROPY_REFRESH_HASH_CNT.</ipxact:description>
            <ipxact:bitOffset>9</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>err_processed</ipxact:name>
            <ipxact:description>When error occurs and one of the state machine stays at
Error handling state, SW may process the error based on
ERR_CODE, then let FSM back to the reset state</ipxact:description>
            <ipxact:bitOffset>10</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>STATUS</ipxact:name>
          <ipxact:addressOffset>'h1c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>sha3_idle</ipxact:name>
            <ipxact:description>If 1, SHA3 hashing engine is in idle state.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>sha3_absorb</ipxact:name>
            <ipxact:description>If 1, SHA3 is receiving message stream and processing it</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>sha3_squeeze</ipxact:name>
            <ipxact:description>If 1, SHA3 completes sponge absorbing stage.
In this stage, SW can manually run the hashing engine.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fifo_depth</ipxact:name>
            <ipxact:description>Count of occupied entries in the message FIFO.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fifo_empty</ipxact:name>
            <ipxact:description>Message FIFO Empty indicator.

The FIFO's `Pass` parameter is set to `1'b 1`. So, by default, if
the SHA engine is ready, the write data to FIFO just passes
through.

In this case, `fifo_depth` remains **0**. `fifo_empty`, however,
lowers the value to **0** for a cycle, then goes back to the empty
state, **1**.

See the &quot;Message FIFO&quot; section in the spec for the reason.</ipxact:description>
            <ipxact:bitOffset>14</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fifo_full</ipxact:name>
            <ipxact:description>Message FIFO Full indicator</ipxact:description>
            <ipxact:bitOffset>15</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ALERT_FATAL_FAULT</ipxact:name>
            <ipxact:description>No fatal fault has occurred inside the KMAC unit (0).
A fatal fault has occurred and the KMAC unit needs to be reset (1),
Examples for such faults include
i) TL-UL bus integrity fault
ii) storage errors in the shadow registers
iii) errors in the message, round, or key counter
iv) any internal FSM entering an invalid state
v) an error in the redundant lfsr</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ALERT_RECOV_CTRL_UPDATE_ERR</ipxact:name>
            <ipxact:description>An update error has not occurred (0) or has occurred (1) in the shadowed Control Register.
KMAC operation needs to be restarted by re-writing the Control Register.</ipxact:description>
            <ipxact:bitOffset>17</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ENTROPY_PERIOD</ipxact:name>
          <ipxact:addressOffset>'h20</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>prescaler</ipxact:name>
            <ipxact:description>EDN Wait timer prescaler.

EDN Wait timer has 16 bit value. The timer value is increased when the timer pulse is generated. Timer pulse is raises when the number of the clock cycles hit this prescaler value.

The exact period of the timer pulse is unknown as the KMAC input clock may contain jitters.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>10</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>wait_timer</ipxact:name>
            <ipxact:description>EDN request wait timer.

The entropy module in KMAC waits up to this field in the timer pulse
after it sends request to EDN module. If the timer expires, the
entropy module moves to an error state and notifies to the system.

If there is a pending EDN request during wait timer update, then this update is delayed until the EDN request is complete.

If 0, the entropy module waits the EDN response always. If EDN does
not respond in this configuration, the software shall reset the IP.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ENTROPY_REFRESH_HASH_CNT</ipxact:name>
          <ipxact:addressOffset>'h24</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>hash_cnt</ipxact:name>
            <ipxact:description>Hash (KMAC) counter</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>10</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ENTROPY_REFRESH_THRESHOLD_SHADOWED</ipxact:name>
          <ipxact:addressOffset>'h28</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>threshold</ipxact:name>
            <ipxact:description>Hash Threshold</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>10</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ENTROPY_SEED</ipxact:name>
          <ipxact:addressOffset>'h2c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>seed</ipxact:name>
            <ipxact:description>32-bit chunk of the entropy generator seed</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>KEY_SHARE0</ipxact:name>
          <ipxact:dim>16</ipxact:dim>
          <ipxact:addressOffset>'h30</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>key_0</ipxact:name>
            <ipxact:description>32-bit chunk of up-to 512-bit Secret Key</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>KEY_SHARE1</ipxact:name>
          <ipxact:dim>16</ipxact:dim>
          <ipxact:addressOffset>'h70</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>key_0</ipxact:name>
            <ipxact:description>32-bit chunk of up-to 512-bit Secret Key</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>KEY_LEN</ipxact:name>
          <ipxact:addressOffset>'hb0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>len</ipxact:name>
            <ipxact:description>Key length choice</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>3</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>PREFIX</ipxact:name>
          <ipxact:dim>11</ipxact:dim>
          <ipxact:addressOffset>'hb4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>prefix_0</ipxact:name>
            <ipxact:description>32-bit chunk of Encoded NS Prefix</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ERR_CODE</ipxact:name>
          <ipxact:addressOffset>'he0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>err_code</ipxact:name>
            <ipxact:description>If the `kmac_err` interrupt occurs, this register has information on the error cause.
Bits 31:24 contain the error code (please refer to `err_code_e` in `hw/ip/kmac/rtl/kmac_pkg.sv`) for the encoding, and bits 23:0 contain additional debug information.
This register does *not* get cleared when the `kmac_err` interrupt state gets cleared.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>csrng</ipxact:name>
        <ipxact:displayName>Cryptographically Secure Random Number Generator</ipxact:displayName>
        <ipxact:description>Takes entropy bits to produce cryptographically secure random numbers for consumption by hardware blocks and by software</ipxact:description>
        <ipxact:baseAddress>'h10915000</ipxact:baseAddress>
        <ipxact:range>'h60</ipxact:range>
        <ipxact:width>32</ipxact:width>
        <ipxact:register>
          <ipxact:name>INTR_STATE</ipxact:name>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>CS_CMD_REQ_DONE</ipxact:name>
            <ipxact:description>Asserted when a command request is completed.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CS_ENTROPY_REQ</ipxact:name>
            <ipxact:description>Asserted when a request for entropy has been made.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CS_HW_INST_EXC</ipxact:name>
            <ipxact:description>Asserted when a hardware-attached CSRNG instance encounters a command exception</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CS_FATAL_ERR</ipxact:name>
            <ipxact:description>Asserted when a FIFO error or a fatal alert occurs. Check the !!ERR_CODE register to get more information.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_ENABLE</ipxact:name>
          <ipxact:addressOffset>'h4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>CS_CMD_REQ_DONE</ipxact:name>
            <ipxact:description>Enable interrupt when !!INTR_STATE.cs_cmd_req_done is set.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CS_ENTROPY_REQ</ipxact:name>
            <ipxact:description>Enable interrupt when !!INTR_STATE.cs_entropy_req is set.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CS_HW_INST_EXC</ipxact:name>
            <ipxact:description>Enable interrupt when !!INTR_STATE.cs_hw_inst_exc is set.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CS_FATAL_ERR</ipxact:name>
            <ipxact:description>Enable interrupt when !!INTR_STATE.cs_fatal_err is set.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_TEST</ipxact:name>
          <ipxact:addressOffset>'h8</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>CS_CMD_REQ_DONE</ipxact:name>
            <ipxact:description>Write 1 to force !!INTR_STATE.cs_cmd_req_done to 1.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CS_ENTROPY_REQ</ipxact:name>
            <ipxact:description>Write 1 to force !!INTR_STATE.cs_entropy_req to 1.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CS_HW_INST_EXC</ipxact:name>
            <ipxact:description>Write 1 to force !!INTR_STATE.cs_hw_inst_exc to 1.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CS_FATAL_ERR</ipxact:name>
            <ipxact:description>Write 1 to force !!INTR_STATE.cs_fatal_err to 1.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ALERT_TEST</ipxact:name>
          <ipxact:addressOffset>'hc</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>RECOV_ALERT</ipxact:name>
            <ipxact:description>Write 1 to trigger one alert event of this kind.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FATAL_ALERT</ipxact:name>
            <ipxact:description>Write 1 to trigger one alert event of this kind.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>REGWEN</ipxact:name>
          <ipxact:addressOffset>'h10</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>REGWEN</ipxact:name>
            <ipxact:description>When true, all writeable registers can be modified.
When false, they become read-only.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CTRL</ipxact:name>
          <ipxact:addressOffset>'h14</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>ENABLE</ipxact:name>
            <ipxact:description>Setting this field to kMultiBitBool4True will enable the CSRNG module. The modules
of the entropy complex may only be enabled and disabled in a specific order, see
Programmers Guide for details.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h9</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:enumeratedValues>
              <ipxact:enumeratedValue>
                <ipxact:name>True</ipxact:name>
                <ipxact:value>'h6</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>False</ipxact:name>
                <ipxact:value>'h9</ipxact:value>
              </ipxact:enumeratedValue>
            </ipxact:enumeratedValues>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SW_APP_ENABLE</ipxact:name>
            <ipxact:description>Setting this field to kMultiBitBool4True will enable reading from the !!GENBITS register.
This application interface for software (register based) will be enabled
only if the otp_en_csrng_sw_app_read input vector is set to the enable encoding.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h9</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:enumeratedValues>
              <ipxact:enumeratedValue>
                <ipxact:name>True</ipxact:name>
                <ipxact:value>'h6</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>False</ipxact:name>
                <ipxact:value>'h9</ipxact:value>
              </ipxact:enumeratedValue>
            </ipxact:enumeratedValues>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>READ_INT_STATE</ipxact:name>
            <ipxact:description>Setting this field to kMultiBitBool4True will enable reading from the !!INT_STATE_VAL register.
Reading the internal state of the enable instances will be enabled
only if the otp_en_csrng_sw_app_read input vector is set to the enable encoding.
Also, the !!INT_STATE_READ_ENABLE bit of the selected instance needs to be set to true for this to work.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h9</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:enumeratedValues>
              <ipxact:enumeratedValue>
                <ipxact:name>True</ipxact:name>
                <ipxact:value>'h6</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>False</ipxact:name>
                <ipxact:value>'h9</ipxact:value>
              </ipxact:enumeratedValue>
            </ipxact:enumeratedValues>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FIPS_FORCE_ENABLE</ipxact:name>
            <ipxact:description>Setting this field to kMultiBitBool4True enables forcing the FIPS/CC compliance flag to true via the !!FIPS_FORCE register.</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h9</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:enumeratedValues>
              <ipxact:enumeratedValue>
                <ipxact:name>True</ipxact:name>
                <ipxact:value>'h6</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>False</ipxact:name>
                <ipxact:value>'h9</ipxact:value>
              </ipxact:enumeratedValue>
            </ipxact:enumeratedValues>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CMD_REQ</ipxact:name>
          <ipxact:addressOffset>'h18</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>CMD_REQ</ipxact:name>
            <ipxact:description>Writing this request with defined CSRNG commands will initiate all
possible CSRNG actions. The application interface must wait for the
&quot;ack&quot; to return before issuing new commands.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>RESEED_INTERVAL</ipxact:name>
          <ipxact:addressOffset>'h1c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>RESEED_INTERVAL</ipxact:name>
            <ipxact:description>Setting this field will set the number of generate requests that can be
made to CSRNG before a reseed request needs to be made.
This register supports a maximum of 2^32 requests between reseeds.
This register will be compared to a counter, which counts the number of
generate commands between reseed or instantiate commands.
If the counter reaches the value of this register, the violating command
will be acknowledged with a status error.
If the violating command was issued by a HW instance, an interrupt will
be triggered.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'hffffffff</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>RESEED_COUNTER_0</ipxact:name>
          <ipxact:addressOffset>'h20</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>RESEED_COUNTER_0</ipxact:name>
            <ipxact:description>Reseed Counter indicating the number of completed Generate requests since the last Instantiate or Reseed command.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>RESEED_COUNTER_1</ipxact:name>
          <ipxact:addressOffset>'h24</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>RESEED_COUNTER_0</ipxact:name>
            <ipxact:description>For RESEED_COUNTER1</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>RESEED_COUNTER_2</ipxact:name>
          <ipxact:addressOffset>'h28</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>RESEED_COUNTER_0</ipxact:name>
            <ipxact:description>For RESEED_COUNTER2</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SW_CMD_STS</ipxact:name>
          <ipxact:addressOffset>'h2c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>CMD_RDY</ipxact:name>
            <ipxact:description>This bit indicates when the command interface is ready to accept commands.
Before starting to write a new command to !!SW_CMD_REQ, this field needs to be polled.
0b0: CSRNG is not ready to accept commands or the last command hasn't been acked yet.
0b1: CSRNG is ready to accept the next command.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CMD_ACK</ipxact:name>
            <ipxact:description>This one bit field indicates when a SW command has been acknowledged by the CSRNG.
It is set to low each time a new command is written to !!CMD_REQ.
The field is set to high once a SW command request has been acknowledged by the CSRNG.
0b0: The last SW command has not been acknowledged yet.
0b1: The last SW command has been acknowledged.
In case of a generate command the acknowledgement goes high after all of the requested entropy is consumed.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CMD_STS</ipxact:name>
            <ipxact:description>This field represents the status code returned with the application command ack.
It is updated each time a command ack is asserted on the internal application
interface for software use.
To check whether a command was successful, wait for !!INTR_STATE.CS_CMD_REQ_DONE or
!!SW_CMD_STS.CMD_ACK to be high and then check the value of this field.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>3</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENBITS_VLD</ipxact:name>
          <ipxact:addressOffset>'h30</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>GENBITS_VLD</ipxact:name>
            <ipxact:description>This bit is set when genbits are available on this application interface after a generate command has been issued.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>GENBITS_FIPS</ipxact:name>
            <ipxact:description>This bit is set when genbits are FIPS/CC compliant.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENBITS</ipxact:name>
          <ipxact:addressOffset>'h34</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>GENBITS</ipxact:name>
            <ipxact:description>Reading this register will get the generated bits that were requested with
the generate request. This register must be read four times for each request
made. For example, an application command generate request with
a `clen` value of 4 requires this register to be read 16 times to get all
of the data out of the FIFO path.
Note that for !!GENBITS to be able to deliver random numbers, also !!CTRL.SW_APP_ENABLE needs to be set to `kMultiBitBool4True`.
In addition, the otp_en_csrng_sw_app_read input needs to be set to `kMultiBitBool8True`.
Otherwise, the register reads as 0.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INT_STATE_READ_ENABLE</ipxact:name>
          <ipxact:addressOffset>'h38</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>INT_STATE_READ_ENABLE</ipxact:name>
            <ipxact:description>Per-instance internal state read enable.
Defines whether the internal state of the corresponding instance is readable via !!INT_STATE_VAL.
Note that for !!INT_STATE_VAL to provide read access to the internal state, also !!CTRL.READ_INT_STATE needs to be set to `kMultiBitBool4True`.
In addition, the otp_en_csrng_sw_app_read input needs to be set to `kMultiBitBool8True`.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h7</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>3</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INT_STATE_READ_ENABLE_REGWEN</ipxact:name>
          <ipxact:addressOffset>'h3c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>INT_STATE_READ_ENABLE_REGWEN</ipxact:name>
            <ipxact:description>INT_STATE_READ_ENABLE register configuration enable bit.
If this is cleared to 0, the INT_STATE_READ_ENABLE register cannot be written anymore.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INT_STATE_NUM</ipxact:name>
          <ipxact:addressOffset>'h40</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>INT_STATE_NUM</ipxact:name>
            <ipxact:description>Setting this field will set the number for which internal state can be
selected for a read access. Up to 16 internal state values can be chosen
from this register. The actual number of valid internal state fields
is set by parameter NumHwApps plus 1 software app. For those selections that point
to reserved locations (greater than NumHwApps plus 1), the returned value
will be zero. Writing this register will also reset the internal read
pointer for the !!INT_STATE_VAL register.
Note: This register should be read back after being written to ensure
that the !!INT_STATE_VAL read back is accurate.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INT_STATE_VAL</ipxact:name>
          <ipxact:addressOffset>'h44</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>INT_STATE_VAL</ipxact:name>
            <ipxact:description>Reading this register will dump out the contents of the selected internal state field.
Since the internal state field is 448 bits wide, it will require 14 reads from this
register to gather the entire field. Once 14 reads have been done, the internal read
pointer (selects 32 bits of the 448 bit field) will reset to zero. The !!INT_STATE_NUM
can be re-written at this time (internal read pointer is also reset), and then
another internal state field can be read.
Note that for !!INT_STATE_VAL to provide read access to the internal state, also !!CTRL.READ_INT_STATE needs to be set to `kMultiBitBool4True`.
In addition, the otp_en_csrng_sw_app_read input needs to be set to `kMultiBitBool8True`.
Also, the !!INT_STATE_READ_ENABLE bit of the selected instance needs to be set to true for this to work.
Otherwise, the register reads as 0.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>FIPS_FORCE</ipxact:name>
          <ipxact:addressOffset>'h48</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>FIPS_FORCE</ipxact:name>
            <ipxact:description>Force the FIPS/CC compliance flag of individual instances to true.
This allows CSRNG to set the output FIPS/CC compliance flag to true despite running in fully deterministic mode (flag0 being true).
This can be useful e.g. for known-answer testing through entropy consumers accepting FIPS/CC compliant entropy only, or when firmware is used to derive FIPS/CC compliant entropy seeds.
After setting a particular bit to 1, the FIPS/CC compliance flag of the corresponding instance will be forced to true upon the next Instantiate or Reseed command.

Note that for this to work, !!CTRL.FIPS_FORCE_ENABLE needs to be set to kMultiBitBool4True.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>3</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>HW_EXC_STS</ipxact:name>
          <ipxact:addressOffset>'h4c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>HW_EXC_STS</ipxact:name>
            <ipxact:description>Reading this register indicates whether one of the CSRNG HW instances has
encountered an exception.  Each bit corresponds to a particular hardware
instance, with bit 0 corresponding to instance HW0, bit 1 corresponding
to instance HW1, and so forth. (To monitor the status of requests made
to the SW instance, check the !!SW_CMD_STS register). Writing a zero to this register
resets the status bits.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>RECOV_ALERT_STS</ipxact:name>
          <ipxact:addressOffset>'h50</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>ENABLE_FIELD_ALERT</ipxact:name>
            <ipxact:description>This bit is set when the ENABLE field in the !!CTRL register is set to
a value other than kMultiBitBool4True or kMultiBitBool4False.
Writing a zero resets this status bit.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SW_APP_ENABLE_FIELD_ALERT</ipxact:name>
            <ipxact:description>This bit is set when the SW_APP_ENABLE field in the !!CTRL register is set to
a value other than kMultiBitBool4True or kMultiBitBool4False.
Writing a zero resets this status bit.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>READ_INT_STATE_FIELD_ALERT</ipxact:name>
            <ipxact:description>This bit is set when the READ_INT_STATE field in the !!CTRL register is set to
a value other than kMultiBitBool4True or kMultiBitBool4False.
Writing a zero resets this status bit.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FIPS_FORCE_ENABLE_FIELD_ALERT</ipxact:name>
            <ipxact:description>This bit is set when the FIPS_FORCE_ENABLE field in the !!CTRL register is set to a value other than kMultiBitBool4True or kMultiBitBool4False.
Writing a zero resets this status bit.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ACMD_FLAG0_FIELD_ALERT</ipxact:name>
            <ipxact:description>This bit is set when the FLAG0 field in the Application Command is set to
a value other than kMultiBitBool4True or kMultiBitBool4False.
Writing a zero resets this status bit.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CS_BUS_CMP_ALERT</ipxact:name>
            <ipxact:description>This bit is set when the software application port genbits bus value is equal
to the prior valid value on the bus, indicating a possible attack.
Writing a zero resets this status bit.</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CMD_STAGE_INVALID_ACMD_ALERT</ipxact:name>
            <ipxact:description>This bit is set when an unsupported/illegal CSRNG command is received by the
main state machine.
The invalid command is ignored and CSRNG continues to operate.
Writing a zero resets this status bit.</ipxact:description>
            <ipxact:bitOffset>13</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CMD_STAGE_INVALID_CMD_SEQ_ALERT</ipxact:name>
            <ipxact:description>This bit is set when an out of order command is received by the main state machine.
This happens when an instantiate command is sent for a state that was already
instantiated or when any command other than instantiate is sent for a state that
wasn't instantiated yet.
The invalid command is ignored and CSRNG continues to operate.
Writing a zero resets this status bit.</ipxact:description>
            <ipxact:bitOffset>14</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CMD_STAGE_RESEED_CNT_ALERT</ipxact:name>
            <ipxact:description>This bit is set when the maximum number of generate requests between reseeds is
exceeded.
The invalid generate command is ignored and CSRNG continues to operate.
Writing a zero resets this status bit.</ipxact:description>
            <ipxact:bitOffset>15</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ERR_CODE</ipxact:name>
          <ipxact:addressOffset>'h54</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SFIFO_CMD_ERR</ipxact:name>
            <ipxact:description>This bit will be set to one when an error has been detected for the
command stage command FIFO. The type of error is reflected in the type status
bits (bits 28 through 30 of this register).
This bit will stay set until the next reset.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SFIFO_GENBITS_ERR</ipxact:name>
            <ipxact:description>This bit will be set to one when an error has been detected for the
command stage genbits FIFO. The type of error is reflected in the type status
bits (bits 28 through 30 of this register).
This bit will stay set until the next reset.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CMD_STAGE_SM_ERR</ipxact:name>
            <ipxact:description>This bit will be set to one when an illegal state has been detected for the
command stage state machine. This error will signal a fatal alert, and also
an interrupt if enabled.
This bit will stay set until the next reset.</ipxact:description>
            <ipxact:bitOffset>20</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>MAIN_SM_ERR</ipxact:name>
            <ipxact:description>This bit will be set to one when an illegal state has been detected for the
main state machine. This error will signal a fatal alert, and also
an interrupt if enabled.
This bit will stay set until the next reset.</ipxact:description>
            <ipxact:bitOffset>21</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CTR_DRBG_SM_ERR</ipxact:name>
            <ipxact:description>This bit will be set to one when an illegal state has been detected for the
ctr_drbg state machine. This error will signal a fatal alert, and also
an interrupt if enabled.
This bit will stay set until the next reset.</ipxact:description>
            <ipxact:bitOffset>22</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>AES_CIPHER_SM_ERR</ipxact:name>
            <ipxact:description>This bit will be set to one when an AES fatal error has been detected.
This error will signal a fatal alert, and also an interrupt if enabled.
This bit will stay set until the next reset.</ipxact:description>
            <ipxact:bitOffset>25</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CTR_ERR</ipxact:name>
            <ipxact:description>This bit will be set to one when a mismatch in any of the hardened counters
has been detected.
This error will signal a fatal alert, and also an interrupt if enabled.
This bit will stay set until the next reset.</ipxact:description>
            <ipxact:bitOffset>26</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FIFO_WRITE_ERR</ipxact:name>
            <ipxact:description>This bit will be set to one when any of the source bits (bits 0 through 15 of this
this register) are asserted as a result of an error pulse generated from
any full FIFO that has been received a write pulse.
This bit will stay set until the next reset.</ipxact:description>
            <ipxact:bitOffset>28</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FIFO_READ_ERR</ipxact:name>
            <ipxact:description>This bit will be set to one when any of the source bits (bits 0 through 15 of this
this register) are asserted as a result of an error pulse generated from
any empty FIFO that has received a read pulse.
This bit will stay set until the next reset.</ipxact:description>
            <ipxact:bitOffset>29</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FIFO_STATE_ERR</ipxact:name>
            <ipxact:description>This bit will be set to one when any of the source bits (bits 0 through 15 of this
this register) are asserted as a result of an error pulse generated from
any FIFO where both the empty and full status bits are set.
This bit will stay set until the next reset.</ipxact:description>
            <ipxact:bitOffset>30</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ERR_CODE_TEST</ipxact:name>
          <ipxact:addressOffset>'h58</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>ERR_CODE_TEST</ipxact:name>
            <ipxact:description>Setting this field will set the bit number for which an error
will be forced in the hardware. This bit number is that same one
found in the !!ERR_CODE register. The action of writing this
register will force an error pulse. The sole purpose of this
register is to test that any error properly propagates to either
an interrupt or an alert.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MAIN_SM_STATE</ipxact:name>
          <ipxact:addressOffset>'h5c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>MAIN_SM_STATE</ipxact:name>
            <ipxact:description>This is the state of the CSRNG main state machine.
See the RTL file `csrng_main_sm` for the meaning of the values.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h37</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>6</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>edn</ipxact:name>
        <ipxact:displayName>Entropy Distribution Network</ipxact:displayName>
        <ipxact:description>Distributes random numbers produced by CSRNG to hardware blocks</ipxact:description>
        <ipxact:baseAddress>'h10915800</ipxact:baseAddress>
        <ipxact:range>'h48</ipxact:range>
        <ipxact:width>32</ipxact:width>
        <ipxact:register>
          <ipxact:name>INTR_STATE</ipxact:name>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>edn_cmd_req_done</ipxact:name>
            <ipxact:description>Asserted when a software CSRNG request has completed.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>edn_fatal_err</ipxact:name>
            <ipxact:description>Asserted when a FIFO error occurs.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_ENABLE</ipxact:name>
          <ipxact:addressOffset>'h4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>edn_cmd_req_done</ipxact:name>
            <ipxact:description>Enable interrupt when !!INTR_STATE.edn_cmd_req_done is set.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>edn_fatal_err</ipxact:name>
            <ipxact:description>Enable interrupt when !!INTR_STATE.edn_fatal_err is set.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_TEST</ipxact:name>
          <ipxact:addressOffset>'h8</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>edn_cmd_req_done</ipxact:name>
            <ipxact:description>Write 1 to force !!INTR_STATE.edn_cmd_req_done to 1.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>edn_fatal_err</ipxact:name>
            <ipxact:description>Write 1 to force !!INTR_STATE.edn_fatal_err to 1.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ALERT_TEST</ipxact:name>
          <ipxact:addressOffset>'hc</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>recov_alert</ipxact:name>
            <ipxact:description>Write 1 to trigger one alert event of this kind.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fatal_alert</ipxact:name>
            <ipxact:description>Write 1 to trigger one alert event of this kind.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>REGWEN</ipxact:name>
          <ipxact:addressOffset>'h10</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>REGWEN</ipxact:name>
            <ipxact:description>When true, the CTRL can be written by software.
When false, this field read-only. Defaults true, write zero to clear.
Note that this needs to be cleared after initial configuration at boot in order to
lock in the listed register settings.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CTRL</ipxact:name>
          <ipxact:addressOffset>'h14</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>EDN_ENABLE</ipxact:name>
            <ipxact:description>Setting this field to kMultiBitBool4True enables the EDN module. The modules of the
entropy complex may only be enabled and disabled in a specific order, see
Programmers Guide for details.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h9</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:enumeratedValues>
              <ipxact:enumeratedValue>
                <ipxact:name>True</ipxact:name>
                <ipxact:value>'h6</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>False</ipxact:name>
                <ipxact:value>'h9</ipxact:value>
              </ipxact:enumeratedValue>
            </ipxact:enumeratedValues>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>BOOT_REQ_MODE</ipxact:name>
            <ipxact:description>Setting this field to kMultiBitBool4True enables the boot-time request mode.
In this mode, EDN automatically sends a boot-time request to the CSRNG application interface.
The purpose of this mode is to request entropy as fast as possible after reset, and during chip boot time.

Note that this takes precedence over the AUTO_REQ_MODE field: If both fields are set, EDN enters boot-time request mode.
If none of the fields are set, EDN enters Software Port Mode upon enabling.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h9</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:enumeratedValues>
              <ipxact:enumeratedValue>
                <ipxact:name>True</ipxact:name>
                <ipxact:value>'h6</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>False</ipxact:name>
                <ipxact:value>'h9</ipxact:value>
              </ipxact:enumeratedValue>
            </ipxact:enumeratedValues>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>AUTO_REQ_MODE</ipxact:name>
            <ipxact:description>Setting this field to kMultiBitBool4True enables auto request mode.
In this mode, EDN automatically sends `generate` and `reseed` command requests to the CSRNG application interface.
The purpose of this mode is to continuously deliver entropy to endpoints without firmware intervention.

For this to work, firmware has to 1) configure the !!GENERATE_CMD, !!RESEED_CMD, and !!MAX_NUM_REQS_BETWEEN_RESEEDS registers, and 2) to issue the first `instantiate` command via the !!SW_CMD_REQ register.
Once this command has been acknowledged by CSRNG, the first `generate` command is sent out automatically, and a `reseed` command is sent after every MAX_NUM_REQS_BETWEEN_RESEEDS number of `generate` commands.

Note that the BOOT_REQ_MODE field takes precedence over this field: If both fields are set, EDN enters boot-time request mode.
If none of the fields are set, EDN enters Software Port Mode upon enabling.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h9</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:enumeratedValues>
              <ipxact:enumeratedValue>
                <ipxact:name>True</ipxact:name>
                <ipxact:value>'h6</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>False</ipxact:name>
                <ipxact:value>'h9</ipxact:value>
              </ipxact:enumeratedValue>
            </ipxact:enumeratedValues>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CMD_FIFO_RST</ipxact:name>
            <ipxact:description>Setting this field to kMultiBitBool4True clears the two command FIFOs: the
RESEED_CMD FIFO and the GENERATE_CMD FIFO. This field must be
set to the reset state by software before any further commands can be issued to
these FIFOs.</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h9</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:enumeratedValues>
              <ipxact:enumeratedValue>
                <ipxact:name>True</ipxact:name>
                <ipxact:value>'h6</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>False</ipxact:name>
                <ipxact:value>'h9</ipxact:value>
              </ipxact:enumeratedValue>
            </ipxact:enumeratedValues>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>BOOT_INS_CMD</ipxact:name>
          <ipxact:addressOffset>'h18</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>BOOT_INS_CMD</ipxact:name>
            <ipxact:description>This field is used as the value for the `instantiate` command at boot time.

See [Command Header](../../csrng/doc/theory_of_operation.md#command-header) for the meaning of the individual bits.
Note that the hardware only supports a value of 0 for the `clen` field.
If `clen` has a different value, EDN will hang.
Fixing this requires disabling and restarting both EDN and CSRNG.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h901</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>BOOT_GEN_CMD</ipxact:name>
          <ipxact:addressOffset>'h1c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>BOOT_GEN_CMD</ipxact:name>
            <ipxact:description>This field is used as the value for the `generate` command at boot time.

See [Command Header](../../csrng/doc/theory_of_operation.md#command-header) for the meaning of the individual bits.
Note that the hardware only supports a value of 0 for the `clen` field.
If `clen` has a different value, EDN will hang.
Fixing this requires disabling and restarting both EDN and CSRNG.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'hfff003</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SW_CMD_REQ</ipxact:name>
          <ipxact:addressOffset>'h20</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SW_CMD_REQ</ipxact:name>
            <ipxact:description>Any CSRNG action can be initiated by writing a CSRNG command to this register.
Before any write operation to this register, firmware must read !!SW_CMD_STS to check whether EDN is ready to receive a new command or the next word of a previously started command.

While !!CTRL.AUTO_REQ_MODE is set, only the first instantiate command has any effect.
After that command has been processed, writes to this register will have no effect on operation, until !!CTRL.AUTO_REQ_MODE is de-asserted and the state machine of EDN enters the `SwPortMode` state.

Refer to the [CSRNG documentation](../../csrng/doc/theory_of_operation.md#general-command-format) for details on the command format.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SW_CMD_STS</ipxact:name>
          <ipxact:addressOffset>'h24</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>CMD_REG_RDY</ipxact:name>
            <ipxact:description>This bit indicates when !!SW_CMD_REQ is ready to accept the next word.
This bit has to be polled before each word of a command is written to !!SW_CMD_REQ.
0b0: The EDN is not ready to accept the next word yet.
0b1: The EDN is ready to accept the next word.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CMD_RDY</ipxact:name>
            <ipxact:description>This bit indicates when the EDN is ready to accept the next command.
Before starting to write a new command to !!SW_CMD_REQ, this field needs to be polled.
0b0: The EDN is not ready to accept commands or the last command hasn't been acked yet.
0b1: The EDN is ready to accept the next command.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CMD_ACK</ipxact:name>
            <ipxact:description>This one bit field indicates when a SW command has been acknowledged by the CSRNG.
It is set to low each time a new command is written to !!SW_CMD_REQ.
The field is set to high once a SW command request has been acknowledged by the CSRNG.
0b0: The last SW command has not been acknowledged yet.
0b1: The last SW command has been acknowledged.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CMD_STS</ipxact:name>
            <ipxact:description>This field represents the status code returned with the CSRNG application command ack.
It is updated each time a SW command is acknowledged by CSRNG.
To check whether a command was successful, wait for !!INTR_STATE.EDN_CMD_REQ_DONE or
!!SW_CMD_STS.CMD_ACK to be high and then check the value of this field.
A description of the command status types can be found [here](../../csrng/doc/registers.md#sw_cmd_sts--cmd_sts).</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>3</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>HW_CMD_STS</ipxact:name>
          <ipxact:addressOffset>'h28</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>BOOT_MODE</ipxact:name>
            <ipxact:description>This one bit field indicates whether the EDN is in the hardware controlled boot mode.
0b0: The EDN is not in boot mode.
0b1: The EDN is in boot mode.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>AUTO_MODE</ipxact:name>
            <ipxact:description>This one bit field indicates whether the EDN is in the hardware controlled part of auto mode.
The instantiate command is issued via SW interface and is thus not part of the hardware controlled part of auto mode.
0b0: The EDN is not in the hardware controlled part of auto mode.
0b1: The EDN is in the hardware controlled part of auto mode.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CMD_TYPE</ipxact:name>
            <ipxact:description>This field contains the application command type of the hardware controlled command issued last.
The application command selects one of five operations to perform.
A description of the application command types can be found [here](../../csrng/doc/theory_of_operation.md#command-description).</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CMD_ACK</ipxact:name>
            <ipxact:description>This one bit field indicates when a HW command has been acknowledged by the CSRNG.
It is set to low each time a new command is sent to the CSRNG.
The field is set to high once a HW command request has been acknowledged by the CSRNG.
0b0: The last HW command has not been acknowledged yet.
0b1: The last HW command has been acknowledged.</ipxact:description>
            <ipxact:bitOffset>6</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CMD_STS</ipxact:name>
            <ipxact:description>This field represents the status code returned with the CSRNG application command ack.
It is updated each time a HW command is acknowledged by CSRNG.
A description of the command status types can be found [here](../../csrng/doc/registers.md#sw_cmd_sts--cmd_sts).</ipxact:description>
            <ipxact:bitOffset>7</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>3</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>RESEED_CMD</ipxact:name>
          <ipxact:addressOffset>'h2c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>RESEED_CMD</ipxact:name>
            <ipxact:description>Writing this register will fill a FIFO with up to 13 command words (32b words).
When running in auto request mode, this FIFO is used to automatically send out a `reseed` command to the CSRNG application interface after every MAX_NUM_REQS_BETWEEN_RESEEDS number of `generate` commands.

See [General Command Format](../../csrng/doc/theory_of_operation.md#general-command-format) for details about the command format.

Note that the number of additional data words provided must match the value of the `clen` field of the first word.
Otherwise, undefined behavior may result.
If more than 13 entries are written to the FIFO, they are ignored and EDN signals an `edn_fatal_err` interrupt as well as a fatal alert.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATE_CMD</ipxact:name>
          <ipxact:addressOffset>'h30</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>GENERATE_CMD</ipxact:name>
            <ipxact:description>Writing this register will fill a FIFO with up to 13 command words (32b words).
When running auto request mode, this FIFO is used to automatically send out `generate` commands to the CSRNG
application interface.

See [General Command Format](../../csrng/doc/theory_of_operation.md#general-command-format) for details about the command format.

Note that the number of additional data words provided must match the value of the `clen` field of the first word.
Otherwise, undefined behavior may result.
If more than 13 entries are written to the FIFO, they are ignored and EDN signals an `edn_fatal_err` interrupt as well as a fatal alert.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MAX_NUM_REQS_BETWEEN_RESEEDS</ipxact:name>
          <ipxact:addressOffset>'h34</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>MAX_NUM_REQS_BETWEEN_RESEEDS</ipxact:name>
            <ipxact:description>Setting this field will set the number of `generate` command requests that are made
to CSRNG before a reseed request is made.
This value only has meaning when running in auto request mode.
This register supports a maximum of 2^32 `generate` requests between reseeds.
This register will be used by a counter that counts down, triggering an automatic `reseed` request when it reaches zero.

Note that this value must be chosen smaller than or equal to the value configured in the [`RESEED_INTERVAL` register of CSRNG](../../csrng/doc/registers.md#reseed-interval).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>RECOV_ALERT_STS</ipxact:name>
          <ipxact:addressOffset>'h38</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>EDN_ENABLE_FIELD_ALERT</ipxact:name>
            <ipxact:description>This bit is set when the EDN_ENABLE field is set to an illegal value,
something other than kMultiBitBool4True or kMultiBitBool4False.
Writing a zero resets this status bit.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>BOOT_REQ_MODE_FIELD_ALERT</ipxact:name>
            <ipxact:description>This bit is set when the BOOT_REQ_MODE field is set to an illegal value,
something other than kMultiBitBool4True or kMultiBitBool4False.
Writing a zero resets this status bit.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>AUTO_REQ_MODE_FIELD_ALERT</ipxact:name>
            <ipxact:description>This bit is set when the !!CTRL.AUTO_REQ_MODE field is set to an illegal value,
something other than kMultiBitBool4True or kMultiBitBool4False.
Writing a zero resets this status bit.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CMD_FIFO_RST_FIELD_ALERT</ipxact:name>
            <ipxact:description>This bit is set when the CMD_FIFO_RST field is set to an illegal value,
something other than kMultiBitBool4True or kMultiBitBool4False.
Writing a zero resets this status bit.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>EDN_BUS_CMP_ALERT</ipxact:name>
            <ipxact:description>This bit is set when the interal entropy bus value is equal to the prior
valid value on the bus, indicating a possible attack.
Writing a zero resets this status bit.</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CSRNG_ACK_ERR</ipxact:name>
            <ipxact:description>This bit is set when the CSRNG returns an acknowledgement where the status signal is non-zero.
Writing a zero resets this status bit.</ipxact:description>
            <ipxact:bitOffset>13</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>zeroToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ERR_CODE</ipxact:name>
          <ipxact:addressOffset>'h3c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SFIFO_RESCMD_ERR</ipxact:name>
            <ipxact:description>This bit will be set to one when an error has been detected for the
reseed command FIFO. The type of error is reflected in the type status
bits (bits 28 through 30 of this register).
When this bit is set, a fatal error condition will result.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SFIFO_GENCMD_ERR</ipxact:name>
            <ipxact:description>This bit will be set to one when an error has been detected for the
generate command FIFO. The type of error is reflected in the type status
bits (bits 28 through 30 of this register).
When this bit is set, a fatal error condition will result.
This bit will stay set until the next reset.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>EDN_ACK_SM_ERR</ipxact:name>
            <ipxact:description>This bit will be set to one when an illegal state has been detected for the
EDN ack stage state machine. This error will signal a fatal alert.
This bit will stay set until the next reset.</ipxact:description>
            <ipxact:bitOffset>20</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>EDN_MAIN_SM_ERR</ipxact:name>
            <ipxact:description>This bit will be set to one when an illegal state has been detected for the
EDN main stage state machine. This error will signal a fatal alert.
This bit will stay set until the next reset.</ipxact:description>
            <ipxact:bitOffset>21</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>EDN_CNTR_ERR</ipxact:name>
            <ipxact:description>This bit will be set to one when a hardened counter has detected an error
condition. This error will signal a fatal alert.
This bit will stay set until the next reset.</ipxact:description>
            <ipxact:bitOffset>22</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FIFO_WRITE_ERR</ipxact:name>
            <ipxact:description>This bit will be set to one when any of the source bits (bits 0 through 1 of this register) are asserted as a result of an error pulse generated from any full FIFO that has received a write pulse.
This bit will stay set until the next reset.</ipxact:description>
            <ipxact:bitOffset>28</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FIFO_READ_ERR</ipxact:name>
            <ipxact:description>This bit will be set to one when any of the source bits (bits 0 through 1 of this register) are asserted as a result of an error pulse generated from any empty FIFO that has received a read pulse.
This bit will stay set until the next reset.</ipxact:description>
            <ipxact:bitOffset>29</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FIFO_STATE_ERR</ipxact:name>
            <ipxact:description>This bit will be set to one when any of the source bits (bits 0 through 1 of this register) are asserted as a result of an error pulse generated from any FIFO where both the empty and full status bits are set or in case of error conditions inside the hardened counters.
This bit will stay set until the next reset.</ipxact:description>
            <ipxact:bitOffset>30</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ERR_CODE_TEST</ipxact:name>
          <ipxact:addressOffset>'h40</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>ERR_CODE_TEST</ipxact:name>
            <ipxact:description>Setting this field will set the bit number for which an error
will be forced in the hardware. This bit number is that same one
found in the !!ERR_CODE register. The action of writing this
register will force an error pulse. The sole purpose of this
register is to test that any error properly propagates to either
an interrupt or an alert.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MAIN_SM_STATE</ipxact:name>
          <ipxact:addressOffset>'h44</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>MAIN_SM_STATE</ipxact:name>
            <ipxact:description>This is the state of the EDN main state machine.
See the RTL file `edn_main_sm` for the meaning of the values.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'hc1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>9</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>entropy_source</ipxact:name>
        <ipxact:displayName>Entropy Source Address Map</ipxact:displayName>
        <ipxact:description>Entropy-source configuration, status, and data registers.</ipxact:description>
        <ipxact:baseAddress>'h10916000</ipxact:baseAddress>
        <ipxact:range>'h17c</ipxact:range>
        <ipxact:width>32</ipxact:width>
        <ipxact:register>
          <ipxact:name>COMPONENT_ID</ipxact:name>
          <ipxact:description>Identifies the entropy-source register interface.</ipxact:description>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>NAME</ipxact:name>
            <ipxact:description>Entropy-source component identifier.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>MINOR_VERSION</ipxact:name>
            <ipxact:description>Minor interface version.</ipxact:description>
            <ipxact:bitOffset>24</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>MAJOR_VERSION</ipxact:name>
            <ipxact:description>Major interface version.</ipxact:description>
            <ipxact:bitOffset>28</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CTRL</ipxact:name>
          <ipxact:description>Controls entropy generation and conditioning.</ipxact:description>
          <ipxact:addressOffset>'h4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>RSVD0</ipxact:name>
            <ipxact:description>Reserved; reads zero and ignores writes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>MODULE_ENABLE</ipxact:name>
            <ipxact:description>Enables startup health testing and entropy output. Clearing this field holds the main state machine idle. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>AUTOTUNE_ENABLE</ipxact:name>
            <ipxact:description>Enables per-generator automatic detuning after a lane health-test failure. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>BYPASS_ENTROPY_COMPRESSOR</ipxact:name>
            <ipxact:description>Bypasses BIW extraction and writes the twelve generator bytes to the FIFO as three 32-bit words, word 0 first, with generator 4n+k in bits [8k+7:8k] of word n. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>DOWNSAMPLE_RATE</ipxact:name>
            <ipxact:description>Selects every (N+1)th decorrelator output while BIW extraction is bypassed. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>10</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SHA256_WHITENING_ENABLE</ipxact:name>
            <ipxact:description>Enables SHA-256 conditioning of each 512-bit BIW input block into a 256-bit digest. When clear, BIW words pass directly to the FIFO. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>28</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>DEBUG_CTRL</ipxact:name>
          <ipxact:description>Controls the external debug observation pin. FIPS_LOCK.LOCK prevents software changes to the signal selection and divider.</ipxact:description>
          <ipxact:addressOffset>'hc</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SELECT_SIGNAL</ipxact:name>
            <ipxact:description>Selects the observed signal: generator noise bits [11:0], sample clocks [27:16], BIW data [63:32], FIFO input [95:64], or generator bytes [223:128]. Other selections drive the divider input low. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SELECT_FREQ_DIV</ipxact:name>
            <ipxact:description>Selects observation division by 1, 2, 4, 8, 16, 32, 64, or 128. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>3</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_STATUS</ipxact:name>
          <ipxact:description>Reports latched interrupt status; write one to clear a bit.</ipxact:description>
          <ipxact:addressOffset>'h10</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>HEALTH_TEST_FAILED</ipxact:name>
            <ipxact:description>Indicates a failure in the 32-bit entropy-stream health tests. Write one to clear.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FIFO_ERROR</ipxact:name>
            <ipxact:description>Indicates a FIFO integrity error. Write one to clear.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FIFO_OVERFLOW</ipxact:name>
            <ipxact:description>Indicates that a main FIFO write was discarded while full. Write one to clear.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FIFO_UNDERFLOW</ipxact:name>
            <ipxact:description>Indicates that software read the empty main FIFO. Write one to clear.</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>PERSISTENT_FAILURE</ipxact:name>
            <ipxact:description>Indicates a persistent health-test failure or health-test counter error. Write one to clear.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>AUTOTUNE_FAIL</ipxact:name>
            <ipxact:description>Indicates a per-generator health-test failure while automatic detuning is enabled. Write one to clear.</ipxact:description>
            <ipxact:bitOffset>20</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>BIW_OBS_OVERFLOW</ipxact:name>
            <ipxact:description>Indicates that a BIW observe FIFO word was discarded while full. Write one to clear.</ipxact:description>
            <ipxact:bitOffset>24</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>NOISE_OBS_OVERFLOW</ipxact:name>
            <ipxact:description>Indicates that a raw-noise observe FIFO word was discarded while full. Write one to clear.</ipxact:description>
            <ipxact:bitOffset>28</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_ENABLE</ipxact:name>
          <ipxact:description>Enables individual interrupt sources.</ipxact:description>
          <ipxact:addressOffset>'h14</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>HEALTH_TEST_FAILED</ipxact:name>
            <ipxact:description>Enables the health-test failure interrupt.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FIFO_ERROR</ipxact:name>
            <ipxact:description>Enables the FIFO integrity-error interrupt.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FIFO_OVERFLOW</ipxact:name>
            <ipxact:description>Enables the main FIFO overflow interrupt.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FIFO_UNDERFLOW</ipxact:name>
            <ipxact:description>Enables the main FIFO underflow interrupt.</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>PERSISTENT_FAILURE</ipxact:name>
            <ipxact:description>Enables the persistent-failure interrupt.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>AUTOTUNE_FAIL</ipxact:name>
            <ipxact:description>Enables the automatic-detuning failure interrupt.</ipxact:description>
            <ipxact:bitOffset>20</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>BIW_OBS_OVERFLOW</ipxact:name>
            <ipxact:description>Enables the BIW observe FIFO overflow interrupt.</ipxact:description>
            <ipxact:bitOffset>24</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>NOISE_OBS_OVERFLOW</ipxact:name>
            <ipxact:description>Enables the raw-noise observe FIFO overflow interrupt.</ipxact:description>
            <ipxact:bitOffset>28</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_TEST</ipxact:name>
          <ipxact:description>Triggers individual interrupt sources for testing.</ipxact:description>
          <ipxact:addressOffset>'h18</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>HEALTH_TEST_FAILED</ipxact:name>
            <ipxact:description>Write one to pulse the health-test failure interrupt source.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FIFO_ERROR</ipxact:name>
            <ipxact:description>Write one to pulse the FIFO integrity-error interrupt source.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FIFO_OVERFLOW</ipxact:name>
            <ipxact:description>Write one to pulse the main FIFO overflow interrupt source.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FIFO_UNDERFLOW</ipxact:name>
            <ipxact:description>Write one to pulse the main FIFO underflow interrupt source.</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>PERSISTENT_FAILURE</ipxact:name>
            <ipxact:description>Write one to pulse the persistent-failure interrupt source.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>AUTOTUNE_FAIL</ipxact:name>
            <ipxact:description>Write one to pulse the automatic-detuning failure interrupt source.</ipxact:description>
            <ipxact:bitOffset>20</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>BIW_OBS_OVERFLOW</ipxact:name>
            <ipxact:description>Write one to pulse the BIW observe FIFO overflow interrupt source.</ipxact:description>
            <ipxact:bitOffset>24</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>NOISE_OBS_OVERFLOW</ipxact:name>
            <ipxact:description>Write one to pulse the raw-noise observe FIFO overflow interrupt source.</ipxact:description>
            <ipxact:bitOffset>28</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SHA256_STATUS</ipxact:name>
          <ipxact:description>Reports SHA-256 conditioner progress.</ipxact:description>
          <ipxact:addressOffset>'h1c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>BUSY</ipxact:name>
            <ipxact:description>Indicates that SHA-256 processing or digest output is active.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>INPUT_COUNT</ipxact:name>
            <ipxact:description>Number of 32-bit words currently accumulated in the 512-bit input block.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>OUTPUT_COUNT</ipxact:name>
            <ipxact:description>Number of 32-bit digest words remaining for output. Reports 8 when a digest becomes available, decrements through 0 as words are accepted, and remains 0 while idle or bypassed.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>FIFO_CTRL</ipxact:name>
          <ipxact:description>Controls the 64-entry main entropy FIFO.</ipxact:description>
          <ipxact:addressOffset>'h20</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>ENABLE</ipxact:name>
            <ipxact:description>Enables FIFO writes. Reads remain available while writes are disabled. Words offered to the FIFO are also the DRBG seed stream, which this field does not gate. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ENTROPY_CHURN_ENABLE</ipxact:name>
            <ipxact:description>XORs each incoming word with the FIFO entry 32 positions ahead of the write pointer. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>FIFO_STATUS</ipxact:name>
          <ipxact:description>Reports main FIFO occupancy and pointers.</ipxact:description>
          <ipxact:addressOffset>'h24</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>LEVEL</ipxact:name>
            <ipxact:description>Number of valid 32-bit words in the FIFO.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>7</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>WPTR</ipxact:name>
            <ipxact:description>Current FIFO write pointer.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>6</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>RPTR</ipxact:name>
            <ipxact:description>Current FIFO read pointer.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>6</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>FIFO_RDATA</ipxact:name>
          <ipxact:description>Provides the next main FIFO word.</ipxact:description>
          <ipxact:addressOffset>'h28</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>RDATA</ipxact:name>
            <ipxact:description>Returns and removes the next FIFO word. Reading an empty FIFO sets INTR_STATUS.FIFO_UNDERFLOW and returns undefined data.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
            <ipxact:readAction>modify</ipxact:readAction>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>HEALTH_TEST_CTRL</ipxact:name>
          <ipxact:description>Controls continuous entropy health tests.</ipxact:description>
          <ipxact:addressOffset>'h30</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>ENABLE</ipxact:name>
            <ipxact:description>Enables the repetition-count, adaptive-proportion, and Markov tests in bits 0, 1, and 2. Disabling a test clears its state.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h7</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>3</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>REPETITION_LIMIT</ipxact:name>
            <ipxact:description>Maximum allowed per-lane repetition count before the test fails. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h19</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>HEALTH_TEST_WINDOW_SIZE</ipxact:name>
          <ipxact:description>Sets the APT and Markov window length.</ipxact:description>
          <ipxact:addressOffset>'h34</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SIZE</ipxact:name>
            <ipxact:description>Number of valid entropy words per APT and Markov window. FIPS_LOCK.LOCK requires a value of at least 1024 and prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h800</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MARKOV_TEST_PROB_THRESHOLDS</ipxact:name>
          <ipxact:description>Sets high and low Markov alternation-count thresholds.</ipxact:description>
          <ipxact:addressOffset>'h38</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>PROB_01_THRESHOLD</ipxact:name>
            <ipxact:description>Maximum allowed per-lane alternation count at the window boundary. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h4b0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>PROB_10_THRESHOLD</ipxact:name>
            <ipxact:description>Minimum allowed per-lane alternation count at the window boundary. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h64</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>HEALTH_TEST_STATUS</ipxact:name>
          <ipxact:description>Latches 32-bit stream health-test failures: repetition [0], APT high or low [3], Markov high [4], and Markov low [5]. Write one to clear.</ipxact:description>
          <ipxact:addressOffset>'h40</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>HEALTH_STATUS</ipxact:name>
            <ipxact:description>Latched health-test failure bits; write one to clear.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>REPETITION_TEST_COUNT</ipxact:name>
          <ipxact:description>Reports the highest current repetition count.</ipxact:description>
          <ipxact:addressOffset>'h44</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>REPETITION_COUNT</ipxact:name>
            <ipxact:description>Highest current repetition count among the 32 entropy lanes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>APT_PATTERN_COUNT_1BIT</ipxact:name>
          <ipxact:description>Reports the highest per-lane APT one-count in the current window.</ipxact:description>
          <ipxact:addressOffset>'h50</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>PATTERN_COUNT</ipxact:name>
            <ipxact:description>Highest current one-count among the 32 entropy lanes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>APT_PATTERN_COUNT_2BIT</ipxact:name>
          <ipxact:description>Reports the lowest per-lane APT one-count in the current window.</ipxact:description>
          <ipxact:addressOffset>'h54</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>PATTERN_COUNT</ipxact:name>
            <ipxact:description>Lowest current one-count among the 32 entropy lanes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>APT_PROPORTION_1BIT</ipxact:name>
          <ipxact:description>Sets the APT high one-count threshold.</ipxact:description>
          <ipxact:addressOffset>'h60</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>LIMIT</ipxact:name>
            <ipxact:description>Maximum allowed per-lane one-count at the window boundary. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h4b0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>APT_PROPORTION_LO</ipxact:name>
          <ipxact:description>Sets the APT low one-count threshold.</ipxact:description>
          <ipxact:addressOffset>'h70</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>LIMIT</ipxact:name>
            <ipxact:description>Minimum allowed per-lane one-count at the window boundary. Zero disables the low-side test. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h350</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MARKOV_TEST_COUNTS_0</ipxact:name>
          <ipxact:description>Reports the highest and lowest per-lane alternation counts in the current Markov window.</ipxact:description>
          <ipxact:addressOffset>'h80</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>COUNT_01</ipxact:name>
            <ipxact:description>Highest current per-lane alternation count.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>COUNT_10</ipxact:name>
            <ipxact:description>Lowest current per-lane alternation count.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>RING_OSC_ENABLE</ipxact:name>
          <ipxact:description>Controls noise and sample-clock ring oscillators.</ipxact:description>
          <ipxact:addressOffset>'h90</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>ENABLE</ipxact:name>
            <ipxact:description>Enables each generator noise ring oscillator. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'hfff</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>12</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SAMPLE_CLK_ENABLE</ipxact:name>
            <ipxact:description>Enables the shared sample-clock ring oscillator when any bit is set. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'hfff</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>12</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>RING_OSC_TUNE</ipxact:name>
          <ipxact:description>Selects detuned ring-oscillator tap points.</ipxact:description>
          <ipxact:addressOffset>'h94</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>DETUNE</ipxact:name>
            <ipxact:description>Selects the full-length (longer) tap for each noise ring oscillator, lowering its frequency, while automatic tuning is disabled; the reset value (clear) selects the shorter tap. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>12</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SAMPLE_CLK_DETUNE</ipxact:name>
            <ipxact:description>Selects the full-length (longer) shared sample-clock oscillator tap, lowering its frequency, when any bit is set. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>12</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>RING_OSC_CTRL</ipxact:name>
          <ipxact:description>Selects each generator sample-clock source.</ipxact:description>
          <ipxact:addressOffset>'h98</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SAMPLE_CLK_SELECT</ipxact:name>
            <ipxact:description>Selects the shared internal sample clock when set and the external sample clock when clear. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'hfff</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>12</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>DECORRELATOR_CTRL</ipxact:name>
          <ipxact:description>Controls generator decorrelation and byte cadence.</ipxact:description>
          <ipxact:addressOffset>'ha0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>BYPASS</ipxact:name>
            <ipxact:description>Bypasses the LFSR feedback path independently for each generator. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>12</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SAMPLE_CLK_DIV</ipxact:name>
            <ipxact:description>Sets the generator byte-output period to this value plus one sample-clock cycles. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h3f</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>20</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>DECORRELATOR_MASK</ipxact:name>
          <ipxact:description>Masks bits in every generator entropy byte.</ipxact:description>
          <ipxact:addressOffset>'ha4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>ENTROPY_BYTE_MASK</ipxact:name>
            <ipxact:description>Enables corresponding entropy-byte bits when set. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'hff</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MAIN_SM_STATUS</ipxact:name>
          <ipxact:description>Reports the startup health-test gate state machine.</ipxact:description>
          <ipxact:addressOffset>'hb4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>STATE</ipxact:name>
            <ipxact:description>Current sparse-encoded state-machine state.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>9</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>IDLE</ipxact:name>
            <ipxact:description>Indicates that the state machine is idle.</ipxact:description>
            <ipxact:bitOffset>9</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ALERT</ipxact:name>
            <ipxact:description>Latches entry into the persistent-failure alert path, which halts entropy output. Write one or reset the block to clear.</ipxact:description>
            <ipxact:bitOffset>10</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ERR</ipxact:name>
            <ipxact:description>Latches an illegal state or health-test counter integrity error. Write one or reset the block to clear.</ipxact:description>
            <ipxact:bitOffset>11</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>BOOT_PHASE_DONE</ipxact:name>
            <ipxact:description>Indicates successful completion of startup health testing and permits entropy output.</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ALERT_CNTR_CLR_OK</ipxact:name>
            <ipxact:description>Indicates that a passing window may clear alert failure counters.</ipxact:description>
            <ipxact:bitOffset>13</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_0_HEALTH_STATUS</ipxact:name>
          <ipxact:description>Latches generator 0 health-test failures; write one to clear.</ipxact:description>
          <ipxact:addressOffset>'hc0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:description>Generator 0 failure bits use the HEALTH_TEST_STATUS allocation.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_1_HEALTH_STATUS</ipxact:name>
          <ipxact:description>Latches generator 1 health-test failures; write one to clear.</ipxact:description>
          <ipxact:addressOffset>'hc4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:description>Generator 1 failure bits use the HEALTH_TEST_STATUS allocation.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_2_HEALTH_STATUS</ipxact:name>
          <ipxact:description>Latches generator 2 health-test failures; write one to clear.</ipxact:description>
          <ipxact:addressOffset>'hc8</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:description>Generator 2 failure bits use the HEALTH_TEST_STATUS allocation.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_3_HEALTH_STATUS</ipxact:name>
          <ipxact:description>Latches generator 3 health-test failures; write one to clear.</ipxact:description>
          <ipxact:addressOffset>'hcc</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:description>Generator 3 failure bits use the HEALTH_TEST_STATUS allocation.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_4_HEALTH_STATUS</ipxact:name>
          <ipxact:description>Latches generator 4 health-test failures; write one to clear.</ipxact:description>
          <ipxact:addressOffset>'hd0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:description>Generator 4 failure bits use the HEALTH_TEST_STATUS allocation.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_5_HEALTH_STATUS</ipxact:name>
          <ipxact:description>Latches generator 5 health-test failures; write one to clear.</ipxact:description>
          <ipxact:addressOffset>'hd4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:description>Generator 5 failure bits use the HEALTH_TEST_STATUS allocation.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_6_HEALTH_STATUS</ipxact:name>
          <ipxact:description>Latches generator 6 health-test failures; write one to clear.</ipxact:description>
          <ipxact:addressOffset>'hd8</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:description>Generator 6 failure bits use the HEALTH_TEST_STATUS allocation.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_7_HEALTH_STATUS</ipxact:name>
          <ipxact:description>Latches generator 7 health-test failures; write one to clear.</ipxact:description>
          <ipxact:addressOffset>'hdc</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:description>Generator 7 failure bits use the HEALTH_TEST_STATUS allocation.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_8_HEALTH_STATUS</ipxact:name>
          <ipxact:description>Latches generator 8 health-test failures; write one to clear.</ipxact:description>
          <ipxact:addressOffset>'he0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:description>Generator 8 failure bits use the HEALTH_TEST_STATUS allocation.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_9_HEALTH_STATUS</ipxact:name>
          <ipxact:description>Latches generator 9 health-test failures; write one to clear.</ipxact:description>
          <ipxact:addressOffset>'he4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:description>Generator 9 failure bits use the HEALTH_TEST_STATUS allocation.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_10_HEALTH_STATUS</ipxact:name>
          <ipxact:description>Latches generator 10 health-test failures; write one to clear.</ipxact:description>
          <ipxact:addressOffset>'he8</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:description>Generator 10 failure bits use the HEALTH_TEST_STATUS allocation.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_11_HEALTH_STATUS</ipxact:name>
          <ipxact:description>Latches generator 11 health-test failures; write one to clear.</ipxact:description>
          <ipxact:addressOffset>'hec</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:description>Generator 11 failure bits use the HEALTH_TEST_STATUS allocation.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_0_SAMPLE_CLK_CONFIG</ipxact:name>
          <ipxact:description>Controls generator 0 sample-clock division.</ipxact:description>
          <ipxact:addressOffset>'h100</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SAMPLE_CLK_DIVIDE</ipxact:name>
            <ipxact:description>Selects division by 1, 2, 4, 8, 16, or 32. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_1_SAMPLE_CLK_CONFIG</ipxact:name>
          <ipxact:description>Controls generator 1 sample-clock division.</ipxact:description>
          <ipxact:addressOffset>'h104</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SAMPLE_CLK_DIVIDE</ipxact:name>
            <ipxact:description>Selects division by 1, 2, 4, 8, 16, or 32. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_2_SAMPLE_CLK_CONFIG</ipxact:name>
          <ipxact:description>Controls generator 2 sample-clock division.</ipxact:description>
          <ipxact:addressOffset>'h108</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SAMPLE_CLK_DIVIDE</ipxact:name>
            <ipxact:description>Selects division by 1, 2, 4, 8, 16, or 32. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_3_SAMPLE_CLK_CONFIG</ipxact:name>
          <ipxact:description>Controls generator 3 sample-clock division.</ipxact:description>
          <ipxact:addressOffset>'h10c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SAMPLE_CLK_DIVIDE</ipxact:name>
            <ipxact:description>Selects division by 1, 2, 4, 8, 16, or 32. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_4_SAMPLE_CLK_CONFIG</ipxact:name>
          <ipxact:description>Controls generator 4 sample-clock division.</ipxact:description>
          <ipxact:addressOffset>'h110</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SAMPLE_CLK_DIVIDE</ipxact:name>
            <ipxact:description>Selects division by 1, 2, 4, 8, 16, or 32. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h2</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_5_SAMPLE_CLK_CONFIG</ipxact:name>
          <ipxact:description>Controls generator 5 sample-clock division.</ipxact:description>
          <ipxact:addressOffset>'h114</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SAMPLE_CLK_DIVIDE</ipxact:name>
            <ipxact:description>Selects division by 1, 2, 4, 8, 16, or 32. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h2</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_6_SAMPLE_CLK_CONFIG</ipxact:name>
          <ipxact:description>Controls generator 6 sample-clock division.</ipxact:description>
          <ipxact:addressOffset>'h118</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SAMPLE_CLK_DIVIDE</ipxact:name>
            <ipxact:description>Selects division by 1, 2, 4, 8, 16, or 32. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_7_SAMPLE_CLK_CONFIG</ipxact:name>
          <ipxact:description>Controls generator 7 sample-clock division.</ipxact:description>
          <ipxact:addressOffset>'h11c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SAMPLE_CLK_DIVIDE</ipxact:name>
            <ipxact:description>Selects division by 1, 2, 4, 8, 16, or 32. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_8_SAMPLE_CLK_CONFIG</ipxact:name>
          <ipxact:description>Controls generator 8 sample-clock division.</ipxact:description>
          <ipxact:addressOffset>'h120</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SAMPLE_CLK_DIVIDE</ipxact:name>
            <ipxact:description>Selects division by 1, 2, 4, 8, 16, or 32. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_9_SAMPLE_CLK_CONFIG</ipxact:name>
          <ipxact:description>Controls generator 9 sample-clock division.</ipxact:description>
          <ipxact:addressOffset>'h124</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SAMPLE_CLK_DIVIDE</ipxact:name>
            <ipxact:description>Selects division by 1, 2, 4, 8, 16, or 32. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_10_SAMPLE_CLK_CONFIG</ipxact:name>
          <ipxact:description>Controls generator 10 sample-clock division.</ipxact:description>
          <ipxact:addressOffset>'h128</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SAMPLE_CLK_DIVIDE</ipxact:name>
            <ipxact:description>Selects division by 1, 2, 4, 8, 16, or 32. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h2</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>GENERATOR_11_SAMPLE_CLK_CONFIG</ipxact:name>
          <ipxact:description>Controls generator 11 sample-clock division.</ipxact:description>
          <ipxact:addressOffset>'h12c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SAMPLE_CLK_DIVIDE</ipxact:name>
            <ipxact:description>Selects division by 1, 2, 4, 8, 16, or 32. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h2</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>HT_WATERMARK_NUM</ipxact:name>
          <ipxact:description>Selects the counter and direction for the shared health-test watermark. Changing the selection preserves the current watermark.</ipxact:description>
          <ipxact:addressOffset>'h130</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>WATERMARK_NUM</ipxact:name>
            <ipxact:description>Selects the watermark source. Unsupported values select REPCNT_HI.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:enumeratedValues>
              <ipxact:enumeratedValue>
                <ipxact:name>REPCNT_HI</ipxact:name>
                <ipxact:description>Tracks the highest repetition count.</ipxact:description>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>APT_HI</ipxact:name>
                <ipxact:description>Tracks the highest APT count.</ipxact:description>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>APT_LO</ipxact:name>
                <ipxact:description>Tracks the lowest APT count.</ipxact:description>
                <ipxact:value>'h2</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>MARKOV_HI</ipxact:name>
                <ipxact:description>Tracks the highest Markov count.</ipxact:description>
                <ipxact:value>'h3</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>MARKOV_LO</ipxact:name>
                <ipxact:description>Tracks the lowest Markov count.</ipxact:description>
                <ipxact:value>'h4</ipxact:value>
              </ipxact:enumeratedValue>
            </ipxact:enumeratedValues>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>HT_WATERMARK</ipxact:name>
          <ipxact:description>Reports one selector-dependent watermark. A CTRL.MODULE_ENABLE rising edge arms high modes to zero and low modes to 0xFFFF.</ipxact:description>
          <ipxact:addressOffset>'h134</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>WATERMARK_VALUE</ipxact:name>
            <ipxact:description>Current shared watermark value.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>REPCNT_TOTAL_FAILS</ipxact:name>
          <ipxact:description>Counts repetition-test failures since the last CTRL.MODULE_ENABLE rising edge.</ipxact:description>
          <ipxact:addressOffset>'h138</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>FAIL_COUNT</ipxact:name>
            <ipxact:description>Total repetition-test failure pulses.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>APT_HI_TOTAL_FAILS</ipxact:name>
          <ipxact:description>Counts APT high-threshold failures since the last CTRL.MODULE_ENABLE rising edge.</ipxact:description>
          <ipxact:addressOffset>'h13c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>FAIL_COUNT</ipxact:name>
            <ipxact:description>Total APT high-threshold failure pulses.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>APT_LO_TOTAL_FAILS</ipxact:name>
          <ipxact:description>Counts APT low-threshold failures since the last CTRL.MODULE_ENABLE rising edge.</ipxact:description>
          <ipxact:addressOffset>'h140</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>FAIL_COUNT</ipxact:name>
            <ipxact:description>Total APT low-threshold failure pulses.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MARKOV_HI_TOTAL_FAILS</ipxact:name>
          <ipxact:description>Counts Markov high-threshold failures since the last CTRL.MODULE_ENABLE rising edge.</ipxact:description>
          <ipxact:addressOffset>'h144</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>FAIL_COUNT</ipxact:name>
            <ipxact:description>Total Markov high-threshold failure pulses.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MARKOV_LO_TOTAL_FAILS</ipxact:name>
          <ipxact:description>Counts Markov low-threshold failures since the last CTRL.MODULE_ENABLE rising edge.</ipxact:description>
          <ipxact:addressOffset>'h148</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>FAIL_COUNT</ipxact:name>
            <ipxact:description>Total Markov low-threshold failure pulses.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ALERT_SUMMARY_FAIL_COUNTS</ipxact:name>
          <ipxact:description>Counts consecutive health-test windows containing any failure and clears after an accepted passing window.</ipxact:description>
          <ipxact:addressOffset>'h14c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>ANY_FAIL_COUNT</ipxact:name>
            <ipxact:description>Number of consecutive failing health-test windows.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ALERT_FAIL_COUNTS</ipxact:name>
          <ipxact:description>Reports saturating per-test failure counts for the current alert sequence.</ipxact:description>
          <ipxact:addressOffset>'h150</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>APT_LO_FAIL_COUNT</ipxact:name>
            <ipxact:description>Saturating APT low-threshold failure count.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>APT_HI_FAIL_COUNT</ipxact:name>
            <ipxact:description>Saturating APT high-threshold failure count.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>MARKOV_LO_FAIL_COUNT</ipxact:name>
            <ipxact:description>Saturating Markov low-threshold failure count.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>MARKOV_HI_FAIL_COUNT</ipxact:name>
            <ipxact:description>Saturating Markov high-threshold failure count.</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>REPCNT_FAIL_COUNT</ipxact:name>
            <ipxact:description>Saturating repetition-test failure count.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>FIPS_LOCK</ipxact:name>
          <ipxact:description>Locks entropy generation, conditioning, and health-test configuration against software writes until hardware reset.</ipxact:description>
          <ipxact:addressOffset>'h154</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>LOCK</ipxact:name>
            <ipxact:description>Write one to set the configuration lock. Only hardware reset clears it.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ALERT_THRESHOLD</ipxact:name>
          <ipxact:description>Sets the failing-window count that enters the persistent-failure alert path.</ipxact:description>
          <ipxact:addressOffset>'h158</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>THRESHOLD</ipxact:name>
            <ipxact:description>Number of consecutive failing windows that triggers the alert; zero disables this trigger. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h4</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MIN_ENTROPY_H</ipxact:name>
          <ipxact:description>Stores assessed per-sample min-entropy in unsigned Q4.4 format for advisory threshold calculation.</ipxact:description>
          <ipxact:addressOffset>'h15c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>H</ipxact:name>
            <ipxact:description>Assessed min-entropy in bits per sample. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'hc</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>RECOMMENDED_THRESHOLDS</ipxact:name>
          <ipxact:description>Reports advisory repetition and APT thresholds derived from MIN_ENTROPY_H.</ipxact:description>
          <ipxact:addressOffset>'h160</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>RCT_LIMIT</ipxact:name>
            <ipxact:description>Advisory repetition-count cutoff C = 1 + ceil(20 / H).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>APT_LIMIT</ipxact:name>
            <ipxact:description>Advisory APT high cutoff derived for a 1024-sample window.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>BIW_OBS_CTRL</ipxact:name>
          <ipxact:description>Controls copy-only capture of the post-BIW, pre-SHA stream.</ipxact:description>
          <ipxact:addressOffset>'h164</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>RAW_ENABLE</ipxact:name>
            <ipxact:description>Enables capture after startup health testing completes. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>BIW_OBS_STATUS</ipxact:name>
          <ipxact:description>Reports BIW observe FIFO occupancy and pointers.</ipxact:description>
          <ipxact:addressOffset>'h168</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>LEVEL</ipxact:name>
            <ipxact:description>Number of valid 32-bit words in the BIW observe FIFO.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>7</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>WPTR</ipxact:name>
            <ipxact:description>Current BIW observe FIFO write pointer.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>6</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>RPTR</ipxact:name>
            <ipxact:description>Current BIW observe FIFO read pointer.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>6</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>BIW_OBS_RDATA</ipxact:name>
          <ipxact:description>Provides the next post-BIW, pre-SHA observe word.</ipxact:description>
          <ipxact:addressOffset>'h16c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>RDATA</ipxact:name>
            <ipxact:description>Returns and removes the next BIW observe FIFO word.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
            <ipxact:readAction>modify</ipxact:readAction>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>NOISE_OBS_CTRL</ipxact:name>
          <ipxact:description>Controls copy-only capture of one pre-decorrelator generator lane.</ipxact:description>
          <ipxact:addressOffset>'h170</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>RAW_ENABLE</ipxact:name>
            <ipxact:description>Enables LSB-first packing of selected-lane samples into 32-bit observe words. FIPS_LOCK.LOCK prevents software changes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FLUSH</ipxact:name>
            <ipxact:description>Write one to discard buffered raw-noise words. Changing LANE_SEL also flushes the FIFO.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>LANE_SEL</ipxact:name>
            <ipxact:description>Selects generator lane 0 through 11; other values select lane 0. Changing lanes restarts packing and flushes buffered words.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>NOISE_OBS_STATUS</ipxact:name>
          <ipxact:description>Reports raw-noise observe FIFO occupancy and pointers.</ipxact:description>
          <ipxact:addressOffset>'h174</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>LEVEL</ipxact:name>
            <ipxact:description>Number of valid 32-bit words in the raw-noise observe FIFO.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>7</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>WPTR</ipxact:name>
            <ipxact:description>Current raw-noise observe FIFO write pointer.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>6</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>RPTR</ipxact:name>
            <ipxact:description>Current raw-noise observe FIFO read pointer.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>6</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>NOISE_OBS_RDATA</ipxact:name>
          <ipxact:description>Provides the next packed raw-noise observe word.</ipxact:description>
          <ipxact:addressOffset>'h178</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>RDATA</ipxact:name>
            <ipxact:description>Returns and removes 32 LSB-first pre-decorrelator samples from the selected lane.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
            <ipxact:readAction>modify</ipxact:readAction>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>trng</ipxact:name>
        <ipxact:displayName>External TRNG</ipxact:displayName>
        <ipxact:description>External TRNG register passthrough; the register layout is adopter-defined</ipxact:description>
        <ipxact:baseAddress>'h10917000</ipxact:baseAddress>
        <ipxact:range>'h1000</ipxact:range>
        <ipxact:width>32</ipxact:width>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>sep_lifecycle_ctrl</ipxact:name>
        <ipxact:displayName>SEP Lifecycle Control Address Map</ipxact:displayName>
        <ipxact:description>Lifecycle feature-control and demotion registers with their associated locks.</ipxact:description>
        <ipxact:baseAddress>'h10918000</ipxact:baseAddress>
        <ipxact:range>'h18</ipxact:range>
        <ipxact:width>64</ipxact:width>
        <ipxact:register>
          <ipxact:name>FEAT_CTRL</ipxact:name>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>feature_control</ipxact:name>
            <ipxact:description>Lifecycle feature control bits,</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>64</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>DEMOTE_1</ipxact:name>
          <ipxact:addressOffset>'h8</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>demote</ipxact:name>
            <ipxact:description>Demote bit to enter PROD_DBG state</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>lock</ipxact:name>
            <ipxact:description>Demote lock bit. Once locked, demote can no longer be changed</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Not used</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>62</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>DEMOTE_2</ipxact:name>
          <ipxact:addressOffset>'h10</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>demote</ipxact:name>
            <ipxact:description>Demote bit to enter PROD_DBG state</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>lock</ipxact:name>
            <ipxact:description>Demote lock bit. Once locked, demote can no longer be changed</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Not used</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>62</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>km_mailbox_sep</ipxact:name>
        <ipxact:displayName>Key Manager Mailbox SEP Side</ipxact:displayName>
        <ipxact:description>Register interface for SEP host to access mailbox (write to inbound FIFO, read from outbound FIFO)</ipxact:description>
        <ipxact:baseAddress>'h10920000</ipxact:baseAddress>
        <ipxact:range>'h1c</ipxact:range>
        <ipxact:width>32</ipxact:width>
        <ipxact:register>
          <ipxact:name>SEP_WRITE_DATA</ipxact:name>
          <ipxact:displayName>WRITE_DATA</ipxact:displayName>
          <ipxact:description>Write data to inbound FIFO (SEP→KM messages)</ipxact:description>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>data</ipxact:name>
            <ipxact:displayName>DATA</ipxact:displayName>
            <ipxact:description>32-bit data word to write to inbound FIFO</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEP_WRITE_SEPARATOR</ipxact:name>
          <ipxact:displayName>WRITE_SEPARATOR</ipxact:displayName>
          <ipxact:description>Write 1 to set message separator on next inbound (SEP→KM) write. Cleared by hardware when that write completes.</ipxact:description>
          <ipxact:addressOffset>'h4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>set</ipxact:name>
            <ipxact:displayName>SET</ipxact:displayName>
            <ipxact:description>Write 1 to set message separator on next inbound write. Cleared by hardware when that write completes.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:displayName>RSVD</ipxact:displayName>
            <ipxact:description>Reserved</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>31</ipxact:bitWidth>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEP_READ_DATA</ipxact:name>
          <ipxact:displayName>READ_DATA</ipxact:displayName>
          <ipxact:description>Read data from outbound FIFO (KM→SEP messages)</ipxact:description>
          <ipxact:addressOffset>'h8</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>data</ipxact:name>
            <ipxact:displayName>DATA</ipxact:displayName>
            <ipxact:description>32-bit data word read from outbound FIFO</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEP_STATUS</ipxact:name>
          <ipxact:displayName>STATUS</ipxact:displayName>
          <ipxact:description>FIFO status information</ipxact:description>
          <ipxact:addressOffset>'hc</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>inbound_empty</ipxact:name>
            <ipxact:displayName>INBOUND_EMPTY</ipxact:displayName>
            <ipxact:description>Inbound FIFO is empty (no data available for KM to read)</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>inbound_full</ipxact:name>
            <ipxact:displayName>INBOUND_FULL</ipxact:displayName>
            <ipxact:description>Inbound FIFO is full (cannot write more data)</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>outbound_empty</ipxact:name>
            <ipxact:displayName>OUTBOUND_EMPTY</ipxact:displayName>
            <ipxact:description>Outbound FIFO is empty (no data available for SEP to read)</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>outbound_full</ipxact:name>
            <ipxact:displayName>OUTBOUND_FULL</ipxact:displayName>
            <ipxact:description>Outbound FIFO is full</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>inbound_depth</ipxact:name>
            <ipxact:displayName>INBOUND_DEPTH</ipxact:displayName>
            <ipxact:description>Inbound FIFO fill level (number of words in FIFO)</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>outbound_depth</ipxact:name>
            <ipxact:displayName>OUTBOUND_DEPTH</ipxact:displayName>
            <ipxact:description>Outbound FIFO fill level (number of words in FIFO)</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>inbound_overflow</ipxact:name>
            <ipxact:displayName>INBOUND_OVERFLOW</ipxact:displayName>
            <ipxact:description>Inbound FIFO overflow detected (write attempted when full). Sticky, write 1 to clear.</ipxact:description>
            <ipxact:bitOffset>20</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>outbound_overflow</ipxact:name>
            <ipxact:displayName>OUTBOUND_OVERFLOW</ipxact:displayName>
            <ipxact:description>Outbound FIFO overflow detected (write attempted when full). Sticky, write 1 to clear.</ipxact:description>
            <ipxact:bitOffset>21</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>inbound_underflow</ipxact:name>
            <ipxact:displayName>INBOUND_UNDERFLOW</ipxact:displayName>
            <ipxact:description>Inbound FIFO underflow detected (read attempted when empty). Sticky, write 1 to clear.</ipxact:description>
            <ipxact:bitOffset>22</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>outbound_underflow</ipxact:name>
            <ipxact:displayName>OUTBOUND_UNDERFLOW</ipxact:displayName>
            <ipxact:description>Outbound FIFO underflow detected (read attempted when empty). Sticky, write 1 to clear.</ipxact:description>
            <ipxact:bitOffset>23</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>inbound_separator</ipxact:name>
            <ipxact:displayName>INBOUND_SEPARATOR</ipxact:displayName>
            <ipxact:description>Message separator: 1 if the last word read from inbound FIFO had the separator bit set (last word of message). Read-only, not sticky.</ipxact:description>
            <ipxact:bitOffset>24</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>outbound_separator</ipxact:name>
            <ipxact:displayName>OUTBOUND_SEPARATOR</ipxact:displayName>
            <ipxact:description>Message separator: 1 if the last word read from outbound FIFO had the separator bit set (last word of message). Read-only, not sticky.</ipxact:description>
            <ipxact:bitOffset>25</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:displayName>RSVD</ipxact:displayName>
            <ipxact:description>Reserved</ipxact:description>
            <ipxact:bitOffset>26</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>6</ipxact:bitWidth>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEP_IRQ_STATUS</ipxact:name>
          <ipxact:displayName>IRQ_STATUS</ipxact:displayName>
          <ipxact:description>Interrupt status register</ipxact:description>
          <ipxact:addressOffset>'h10</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>outbound_read_data_avail</ipxact:name>
            <ipxact:displayName>OUTBOUND_READ_DATA_AVAIL</ipxact:displayName>
            <ipxact:description>Outbound FIFO has data available for SEP to read (level-sensitive). 1 = data available, 0 = empty.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>inbound_write_space_avail</ipxact:name>
            <ipxact:displayName>INBOUND_WRITE_SPACE_AVAIL</ipxact:displayName>
            <ipxact:description>Inbound FIFO has space available for SEP to write (level-sensitive). 1 = space available, 0 = full.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>inbound_overflow</ipxact:name>
            <ipxact:displayName>INBOUND_OVERFLOW</ipxact:displayName>
            <ipxact:description>Inbound FIFO overflow detected. Sticky, write 1 to clear.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>outbound_underflow</ipxact:name>
            <ipxact:displayName>OUTBOUND_UNDERFLOW</ipxact:displayName>
            <ipxact:description>Outbound FIFO underflow detected. Sticky, write 1 to clear.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>flushed_by_km</ipxact:name>
            <ipxact:displayName>FLUSHED_BY_KM</ipxact:displayName>
            <ipxact:description>KM performed a mailbox flush. Sticky, write 1 to clear.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:displayName>RSVD</ipxact:displayName>
            <ipxact:description>Reserved</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>27</ipxact:bitWidth>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEP_IRQ_ENABLE</ipxact:name>
          <ipxact:displayName>IRQ_ENABLE</ipxact:displayName>
          <ipxact:description>Interrupt enable register for SEP host</ipxact:description>
          <ipxact:addressOffset>'h14</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>outbound_read_data_avail_en</ipxact:name>
            <ipxact:displayName>OUTBOUND_READ_DATA_AVAIL_EN</ipxact:displayName>
            <ipxact:description>Enable interrupt to SEP when outbound FIFO has data available (KM-&gt;SEP messages)</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>inbound_write_space_avail_en</ipxact:name>
            <ipxact:displayName>INBOUND_WRITE_SPACE_AVAIL_EN</ipxact:displayName>
            <ipxact:description>Enable interrupt to SEP when inbound FIFO has space available (SEP-&gt;KM messages)</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>inbound_overflow_en</ipxact:name>
            <ipxact:displayName>INBOUND_OVERFLOW_EN</ipxact:displayName>
            <ipxact:description>Enable interrupt to SEP when inbound FIFO overflow is detected</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>outbound_underflow_en</ipxact:name>
            <ipxact:displayName>OUTBOUND_UNDERFLOW_EN</ipxact:displayName>
            <ipxact:description>Enable interrupt to SEP when outbound FIFO underflow is detected</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>flushed_by_km_en</ipxact:name>
            <ipxact:displayName>FLUSHED_BY_KM_EN</ipxact:displayName>
            <ipxact:description>Enable interrupt to SEP when KM performs a mailbox flush</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:displayName>RSVD</ipxact:displayName>
            <ipxact:description>Reserved</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>27</ipxact:bitWidth>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEP_CTRL</ipxact:name>
          <ipxact:displayName>CTRL</ipxact:displayName>
          <ipxact:description>Control register for mailbox behavior configuration</ipxact:description>
          <ipxact:addressOffset>'h18</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>inbound_overflow_resp</ipxact:name>
            <ipxact:displayName>INBOUND_OVERFLOW_RESP</ipxact:displayName>
            <ipxact:description>Response type for inbound FIFO overflow: 0=SLVERR (default), 1=OKAY</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>outbound_underflow_resp</ipxact:name>
            <ipxact:displayName>OUTBOUND_UNDERFLOW_RESP</ipxact:displayName>
            <ipxact:description>Response type for outbound FIFO underflow: 0=SLVERR (default), 1=OKAY</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>flush</ipxact:name>
            <ipxact:displayName>FLUSH</ipxact:displayName>
            <ipxact:description>Write 1 to flush all mailbox FIFOs (inbound and outbound). Cleared by hardware when flush completes.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:displayName>RSVD</ipxact:displayName>
            <ipxact:description>Reserved</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>29</ipxact:bitWidth>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>sep_efuse_map</ipxact:name>
        <ipxact:displayName>SEP eFuse Map Address Map</ipxact:displayName>
        <ipxact:description>Shadow registers of the SEP eFuse fields and their per-field write-lock and
read-lock registers. The access properties of each field state the
software access to its shadow register when the field's locks are clear;
a set write lock, a set read lock or secure test mode further restricts
it as the LOCKS register describes.</ipxact:description>
        <ipxact:baseAddress>'h10930000</ipxact:baseAddress>
        <ipxact:range>'h400</ipxact:range>
        <ipxact:width>256</ipxact:width>
        <ipxact:register>
          <ipxact:name>LOCKS</ipxact:name>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>LC_STATE_WRITE_LOCK</ipxact:name>
            <ipxact:description>lc_state_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>LC_STATE_READ_LOCK</ipxact:name>
            <ipxact:description>lc_state_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SBOOT_DIS_WRITE_LOCK</ipxact:name>
            <ipxact:description>sboot_dis_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SBOOT_DIS_READ_LOCK</ipxact:name>
            <ipxact:description>sboot_dis_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>TRANSIENT_RMA_EN_WRITE_LOCK</ipxact:name>
            <ipxact:description>TRANSIENT_RMA_EN_WRITE_LOCK, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>TRANSIENT_RMA_EN_READ_LOCK</ipxact:name>
            <ipxact:description>TRANSIENT_RMA_EN_READ_LOCK, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SIP_DIS_WRITE_LOCK</ipxact:name>
            <ipxact:description>sip_dis_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>6</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SIP_DIS_READ_LOCK</ipxact:name>
            <ipxact:description>sip_dis_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>7</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SYS_DIS_WRITE_LOCK</ipxact:name>
            <ipxact:description>sys_dis_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SYS_DIS_READ_LOCK</ipxact:name>
            <ipxact:description>sys_dis_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>9</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>RMA_SIP_TOKEN_DIGEST_WRITE_LOCK</ipxact:name>
            <ipxact:description>rma_sip_token_digest_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>10</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>RMA_SIP_TOKEN_DIGEST_READ_LOCK</ipxact:name>
            <ipxact:description>rma_sip_token_digest_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>11</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>RMA_CHIPLET_TOKEN_DIGEST_WRITE_LOCK</ipxact:name>
            <ipxact:description>rma_chiplet_token_digest_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>RMA_CHIPLET_TOKEN_DIGEST_READ_LOCK</ipxact:name>
            <ipxact:description>rma_chiplet_token_digest_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>13</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CLASS_KEY_WRITE_LOCK</ipxact:name>
            <ipxact:description>class_key_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>14</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CLASS_KEY_READ_LOCK</ipxact:name>
            <ipxact:description>class_key_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>15</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CHIPLET_PUBK_REVOKE_WRITE_LOCK</ipxact:name>
            <ipxact:description>chiplet_pubk_revoke_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CHIPLET_PUBK_REVOKE_READ_LOCK</ipxact:name>
            <ipxact:description>chiplet_pubk_revoke_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>17</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>BL1_VERSION_WRITE_LOCK</ipxact:name>
            <ipxact:description>bl1_version_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>18</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>BL1_VERSION_READ_LOCK</ipxact:name>
            <ipxact:description>bl1_version_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>19</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>BL2_VERSION_WRITE_LOCK</ipxact:name>
            <ipxact:description>bl2_version_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>20</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>BL2_VERSION_READ_LOCK</ipxact:name>
            <ipxact:description>bl2_version_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>21</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CHIPLET_UID_WRITE_LOCK</ipxact:name>
            <ipxact:description>chiplet_uid_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>22</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CHIPLET_UID_READ_LOCK</ipxact:name>
            <ipxact:description>chiplet_uid_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>23</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SIP_PUBK_HASH0_WRITE_LOCK</ipxact:name>
            <ipxact:description>sip_pubk_hash0_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>24</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SIP_PUBK_HASH0_READ_LOCK</ipxact:name>
            <ipxact:description>sip_pubk_hash0_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>25</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SIP_UID_WRITE_LOCK</ipxact:name>
            <ipxact:description>sip_uid_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>26</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SIP_UID_READ_LOCK</ipxact:name>
            <ipxact:description>sip_uid_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>27</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SYS_PUBK_HASH_WRITE_LOCK</ipxact:name>
            <ipxact:description>sys_pubk_hash_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>28</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SYS_PUBK_HASH_READ_LOCK</ipxact:name>
            <ipxact:description>sys_pubk_hash_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>29</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SYS_UID_WRITE_LOCK</ipxact:name>
            <ipxact:description>sys_uid_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>30</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SYS_UID_READ_LOCK</ipxact:name>
            <ipxact:description>sys_uid_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>31</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>STATUS_RPT_WRITE_LOCK</ipxact:name>
            <ipxact:description>status_rpt_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>32</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>STATUS_RPT_READ_LOCK</ipxact:name>
            <ipxact:description>status_rpt_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>33</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ROM_CTL_WRITE_LOCK</ipxact:name>
            <ipxact:description>rom_ctl_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>34</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ROM_CTL_READ_LOCK</ipxact:name>
            <ipxact:description>rom_ctl_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>35</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SYSCLK_FREQ_MHZ_WRITE_LOCK</ipxact:name>
            <ipxact:description>sysclk_freq_mhz_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>36</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SYSCLK_FREQ_MHZ_READ_LOCK</ipxact:name>
            <ipxact:description>sysclk_freq_mhz_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>37</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CHIPLET_PUBK_HASH0_WRITE_LOCK</ipxact:name>
            <ipxact:description>chiplet_pubk_hash0_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>38</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CHIPLET_PUBK_HASH0_READ_LOCK</ipxact:name>
            <ipxact:description>chiplet_pubk_hash0_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>39</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CHIPLET_PUBK_HASH1_WRITE_LOCK</ipxact:name>
            <ipxact:description>chiplet_pubk_hash1_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>40</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CHIPLET_PUBK_HASH1_READ_LOCK</ipxact:name>
            <ipxact:description>chiplet_pubk_hash1_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>41</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>REQUIRED_SIGNERS_WRITE_LOCK</ipxact:name>
            <ipxact:description>required_signers_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>42</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>REQUIRED_SIGNERS_READ_LOCK</ipxact:name>
            <ipxact:description>required_signers_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>43</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>REQUIRED_ALGS_WRITE_LOCK</ipxact:name>
            <ipxact:description>required_algs_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>44</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>REQUIRED_ALGS_READ_LOCK</ipxact:name>
            <ipxact:description>required_algs_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>45</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CHIPLET_PUBK_PQC_HASH0_WRITE_LOCK</ipxact:name>
            <ipxact:description>chiplet_pubk_pqc_hash0_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>46</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CHIPLET_PUBK_PQC_HASH0_READ_LOCK</ipxact:name>
            <ipxact:description>chiplet_pubk_pqc_hash0_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>47</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CHIPLET_PUBK_PQC_HASH1_WRITE_LOCK</ipxact:name>
            <ipxact:description>chiplet_pubk_pqc_hash1_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>48</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CHIPLET_PUBK_PQC_HASH1_READ_LOCK</ipxact:name>
            <ipxact:description>chiplet_pubk_pqc_hash1_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>49</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SIP_PUBK_PQC_HASH0_WRITE_LOCK</ipxact:name>
            <ipxact:description>sip_pubk_pqc_hash0_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>50</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SIP_PUBK_PQC_HASH0_READ_LOCK</ipxact:name>
            <ipxact:description>sip_pubk_pqc_hash0_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>51</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SYS_PUBK_PQC_HASH_WRITE_LOCK</ipxact:name>
            <ipxact:description>sys_pubk_pqc_hash_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>52</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SYS_PUBK_PQC_HASH_READ_LOCK</ipxact:name>
            <ipxact:description>sys_pubk_pqc_hash_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>53</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SIP_PUBK_HASH1_WRITE_LOCK</ipxact:name>
            <ipxact:description>sip_pubk_hash1_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>54</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SIP_PUBK_HASH1_READ_LOCK</ipxact:name>
            <ipxact:description>sip_pubk_hash1_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>55</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SIP_PUBK_PQC_HASH1_WRITE_LOCK</ipxact:name>
            <ipxact:description>sip_pubk_pqc_hash1_write_lock, when set, this field is not write-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>56</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SIP_PUBK_PQC_HASH1_READ_LOCK</ipxact:name>
            <ipxact:description>sip_pubk_pqc_hash1_read_lock, when set, this field is not read-able (neither the eFuse nor the shadow register)</ipxact:description>
            <ipxact:bitOffset>57</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SEP_CHIPLET_ID_WRITE_LOCK</ipxact:name>
            <ipxact:description>sep_chiplet_id_write_lock (slot 29): when set, SEP_CHIPLET_ID is not write-able.</ipxact:description>
            <ipxact:bitOffset>58</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SEP_CHIPLET_ID_READ_LOCK</ipxact:name>
            <ipxact:description>sep_chiplet_id_read_lock (slot 29): when set, SEP_CHIPLET_ID is not read-able.</ipxact:description>
            <ipxact:bitOffset>59</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SEP_SIP_ID_WRITE_LOCK</ipxact:name>
            <ipxact:description>sep_sip_id_write_lock (slot 30): when set, SEP_SIP_ID is not write-able.</ipxact:description>
            <ipxact:bitOffset>60</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SEP_SIP_ID_READ_LOCK</ipxact:name>
            <ipxact:description>sep_sip_id_read_lock (slot 30): when set, SEP_SIP_ID is not read-able.</ipxact:description>
            <ipxact:bitOffset>61</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SEP_SYS_ID_WRITE_LOCK</ipxact:name>
            <ipxact:description>sep_sys_id_write_lock (slot 31): when set, SEP_SYS_ID is not write-able.</ipxact:description>
            <ipxact:bitOffset>62</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SEP_SYS_ID_READ_LOCK</ipxact:name>
            <ipxact:description>sep_sys_id_read_lock (slot 31): when set, SEP_SYS_ID is not read-able.</ipxact:description>
            <ipxact:bitOffset>63</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>LOCKS_SPARE</ipxact:name>
          <ipxact:addressOffset>'h8</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SPARE0_WRITE_LOCK</ipxact:name>
            <ipxact:description>spare0_write_lock (slot 32): when set, spare0 is not write-able.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPARE0_READ_LOCK</ipxact:name>
            <ipxact:description>spare0_read_lock (slot 32): when set, spare0 is not read-able.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPARE1_WRITE_LOCK</ipxact:name>
            <ipxact:description>spare1_write_lock (slot 33): when set, spare1 is not write-able.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPARE1_READ_LOCK</ipxact:name>
            <ipxact:description>spare1_read_lock (slot 33): when set, spare1 is not read-able.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPARE2_WRITE_LOCK</ipxact:name>
            <ipxact:description>spare2_write_lock (slot 34): when set, spare2 is not write-able.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPARE2_READ_LOCK</ipxact:name>
            <ipxact:description>spare2_read_lock (slot 34): when set, spare2 is not read-able.</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPARE3_WRITE_LOCK</ipxact:name>
            <ipxact:description>spare3_write_lock (slot 35): when set, spare3 is not write-able.</ipxact:description>
            <ipxact:bitOffset>6</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPARE3_READ_LOCK</ipxact:name>
            <ipxact:description>spare3_read_lock (slot 35): when set, spare3 is not read-able.</ipxact:description>
            <ipxact:bitOffset>7</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPARE4_WRITE_LOCK</ipxact:name>
            <ipxact:description>spare4_write_lock (slot 36): when set, spare4 is not write-able.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPARE4_READ_LOCK</ipxact:name>
            <ipxact:description>spare4_read_lock (slot 36): when set, spare4 is not read-able.</ipxact:description>
            <ipxact:bitOffset>9</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPARE5_WRITE_LOCK</ipxact:name>
            <ipxact:description>spare5_write_lock (slot 37): when set, spare5 is not write-able.</ipxact:description>
            <ipxact:bitOffset>10</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPARE5_READ_LOCK</ipxact:name>
            <ipxact:description>spare5_read_lock (slot 37): when set, spare5 is not read-able.</ipxact:description>
            <ipxact:bitOffset>11</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPARE6_WRITE_LOCK</ipxact:name>
            <ipxact:description>spare6_write_lock (slot 38): when set, spare6 is not write-able.</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPARE6_READ_LOCK</ipxact:name>
            <ipxact:description>spare6_read_lock (slot 38): when set, spare6 is not read-able.</ipxact:description>
            <ipxact:bitOffset>13</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPARE7_WRITE_LOCK</ipxact:name>
            <ipxact:description>spare7_write_lock (slot 39): when set, spare7 is not write-able.</ipxact:description>
            <ipxact:bitOffset>14</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPARE7_READ_LOCK</ipxact:name>
            <ipxact:description>spare7_read_lock (slot 39): when set, spare7 is not read-able.</ipxact:description>
            <ipxact:bitOffset>15</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPARE8_WRITE_LOCK</ipxact:name>
            <ipxact:description>spare8_write_lock (slot 40): when set, spare8 is not write-able.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPARE8_READ_LOCK</ipxact:name>
            <ipxact:description>spare8_read_lock (slot 40): when set, spare8 is not read-able.</ipxact:description>
            <ipxact:bitOffset>17</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPARE_LOCK_RSVD</ipxact:name>
            <ipxact:description>Unassigned lock slots 41-47. Reserved for future field lock assignments.</ipxact:description>
            <ipxact:bitOffset>18</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>14</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>LC_STATE</ipxact:name>
          <ipxact:addressOffset>'hc</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>lc_state</ipxact:name>
            <ipxact:description>Life cycle manufacturing state, differentially encoded: {~raw[3:0], raw[3:0]}</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'hf</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Reserved; hardware ignores these bits. A read returns whatever the fuse word or the last write left in them, so software masks reads to lc_state.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>24</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SBOOT_DIS</ipxact:name>
          <ipxact:addressOffset>'h10</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>disable_secure_boot</ipxact:name>
            <ipxact:description>Chicken bit to disable secure boot in SEP ROM.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Unused</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>31</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>TRANSIENT_RMA_EN</ipxact:name>
          <ipxact:addressOffset>'h14</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>transient_rma_en</ipxact:name>
            <ipxact:description>When Transient RMA EN is 1, matching on corresponding *_Tokens will automatically transfer the chip to the corresponding RMA state by setting the LC_STATE reg</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Unused</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>31</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SIP_DIS</ipxact:name>
          <ipxact:description>An owner's feature control vector. When set (1'b1), the corresponding feature is disabled. Layout: see the Disable Vector Format section of lifecycle_controller.adoc.</ipxact:description>
          <ipxact:addressOffset>'h18</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>sep_debug</ipxact:name>
            <ipxact:description>SEP_DBG (bit 0): Coarse-grained debug enable for the SEP scope. 1'b1: SEP-scope debug/scan-dump access disabled and external inbound traffic is filtered. 1'b0: enabled. A local gate only: reaching SEP internal state from an external debugger additionally requires SIP_DBG and CHIPLET_DBG.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>chiplet_dbg</ipxact:name>
            <ipxact:description>CHIPLET_DBG (bit 1): Coarse-grained debug enable for the chiplet scope. 1'b1: chiplet-scope debug/scan-dump access disabled. 1'b0: enabled. Never acts alone: an external debugger reaches chiplet-internal resources only when SIP_DBG is open as well. Contributes to the reachability of the crypto/KM secure chain but never authorizes a dump from it.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>sep_fuse_dbg</ipxact:name>
            <ipxact:description>SEP_FUSE_DBG (bit 2): 1'b1: the DFT-inserted access path into the SEP OTP is disabled. 1'b0: enabled. Also covers the OTP IP-vendor test and calibration interface, which is reachable only over that inserted path. The functional JTAG2AXIL path to the OTP is always available and is not gated by this bit.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>smc_fuse_dbg</ipxact:name>
            <ipxact:description>SMC_FUSE_DBG (bit 3): 1'b1: the DFT-inserted access path into the SMC OTP is disabled. 1'b0: enabled. Produced by SEP-LCC feat_ctrl_o, exported on the SEP boundary, and consumed by SMC to gate its own inserted fuse path.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>debug_reserved_dbg1</ipxact:name>
            <ipxact:description>Reserved for adopter-defined local (DBG_1) debug scan chains (bits 23:4).</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>20</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>sip_debug</ipxact:name>
            <ipxact:description>SIP_DBG (bit 24): Coarse-grained debug enable for the SiP scope: the inter-chiplet debug-bypass gate that admits external (PTAP) debug traffic into this chiplet and forwards it onward to the next chiplet via the outbound JTAG PTAP. 1'b1: disabled. 1'b0: enabled.</ipxact:description>
            <ipxact:bitOffset>24</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>debug_reserved_dbg2</ipxact:name>
            <ipxact:description>Reserved for adopter-defined inter-chiplet-bypass (DBG_2) debug scan chains (bits 47:25).</ipxact:description>
            <ipxact:bitOffset>25</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>23</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>func_reserved</ipxact:name>
            <ipxact:description>Reserved for adopter-defined functional feature gating (bits 63:48).</ipxact:description>
            <ipxact:bitOffset>48</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SYS_DIS</ipxact:name>
          <ipxact:description>An owner's feature control vector. When set (1'b1), the corresponding feature is disabled. Layout: see the Disable Vector Format section of lifecycle_controller.adoc.</ipxact:description>
          <ipxact:addressOffset>'h20</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>sep_debug</ipxact:name>
            <ipxact:description>SEP_DBG (bit 0): Coarse-grained debug enable for the SEP scope. 1'b1: SEP-scope debug/scan-dump access disabled and external inbound traffic is filtered. 1'b0: enabled. A local gate only: reaching SEP internal state from an external debugger additionally requires SIP_DBG and CHIPLET_DBG.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>chiplet_dbg</ipxact:name>
            <ipxact:description>CHIPLET_DBG (bit 1): Coarse-grained debug enable for the chiplet scope. 1'b1: chiplet-scope debug/scan-dump access disabled. 1'b0: enabled. Never acts alone: an external debugger reaches chiplet-internal resources only when SIP_DBG is open as well. Contributes to the reachability of the crypto/KM secure chain but never authorizes a dump from it.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>sep_fuse_dbg</ipxact:name>
            <ipxact:description>SEP_FUSE_DBG (bit 2): 1'b1: the DFT-inserted access path into the SEP OTP is disabled. 1'b0: enabled. Also covers the OTP IP-vendor test and calibration interface, which is reachable only over that inserted path. The functional JTAG2AXIL path to the OTP is always available and is not gated by this bit.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>smc_fuse_dbg</ipxact:name>
            <ipxact:description>SMC_FUSE_DBG (bit 3): 1'b1: the DFT-inserted access path into the SMC OTP is disabled. 1'b0: enabled. Produced by SEP-LCC feat_ctrl_o, exported on the SEP boundary, and consumed by SMC to gate its own inserted fuse path.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>debug_reserved_dbg1</ipxact:name>
            <ipxact:description>Reserved for adopter-defined local (DBG_1) debug scan chains (bits 23:4).</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>20</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>sip_debug</ipxact:name>
            <ipxact:description>SIP_DBG (bit 24): Coarse-grained debug enable for the SiP scope: the inter-chiplet debug-bypass gate that admits external (PTAP) debug traffic into this chiplet and forwards it onward to the next chiplet via the outbound JTAG PTAP. 1'b1: disabled. 1'b0: enabled.</ipxact:description>
            <ipxact:bitOffset>24</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>debug_reserved_dbg2</ipxact:name>
            <ipxact:description>Reserved for adopter-defined inter-chiplet-bypass (DBG_2) debug scan chains (bits 47:25).</ipxact:description>
            <ipxact:bitOffset>25</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>23</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>func_reserved</ipxact:name>
            <ipxact:description>Reserved for adopter-defined functional feature gating (bits 63:48).</ipxact:description>
            <ipxact:bitOffset>48</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>RMA_SIP_TOKEN_DIGEST</ipxact:name>
          <ipxact:addressOffset>'h28</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>token_digest</ipxact:name>
            <ipxact:description>Hash digest of life cycle secret that allows entering RMA_SIP state / Note this is a 256 bit field</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>RMA_CHIPLET_TOKEN_DIGEST</ipxact:name>
          <ipxact:addressOffset>'h48</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>token_digest</ipxact:name>
            <ipxact:description>Hash digest of life cycle secret that allows entering RMA_CHIPLET state/ Note this is a 256 bit field</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CLASS_KEY</ipxact:name>
          <ipxact:addressOffset>'h68</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>key</ipxact:name>
            <ipxact:description>Class key that could be used for FW encryption/decryption</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CHIPLET_PUBK_REVOKE</ipxact:name>
          <ipxact:addressOffset>'h88</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>select</ipxact:name>
            <ipxact:description>Global public-key revocation vector covering every boot-verification key of every owner (classical and PQC). SEP ROM embeds a set of public-key hash digests and accesses additional fused key hashes; each key entry maps to one bit here. Once set, SEP ROM rejects the corresponding key. Bit map: [7:0] ROM chiplet-creator classical keys (bits 0,1 are development keys); [15:8] ROM chiplet-creator PQC keys; [16]/[17] CHIPLET_PUBK_HASH0/1; [18]/[19] CHIPLET_PUBK_PQC_HASH0/1; [20]/[21] SIP_PUBK_HASH0 / SIP_PUBK_PQC_HASH0; [22]/[23] SYS_PUBK_HASH / SYS_PUBK_PQC_HASH; [24]/[25] SIP_PUBK_HASH1 / SIP_PUBK_PQC_HASH1; [31:26] reserved. Before the chiplet owner transfers a part to the customer, the development-key bits shall be set (revoked).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>BL1_VERSION</ipxact:name>
          <ipxact:addressOffset>'h8c</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>version</ipxact:name>
            <ipxact:description>Minimum BL1 version that can be loaded by SEPROM</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>BL2_VERSION</ipxact:name>
          <ipxact:addressOffset>'hac</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>version</ipxact:name>
            <ipxact:description>Minimum BL2 version that can be loaded by BL1. If more boot stages exist, rollback protection can be implemented by BL2.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CHIPLET_UID</ipxact:name>
          <ipxact:addressOffset>'hcc</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>uid</ipxact:name>
            <ipxact:description>Silicon creator's secret device unique ID (also referred to as UDS - Unique Device Secret). The chiplet creator is responsible for CHIPLET_UID provisioning and public identity enrollment. When read-locked, both writability and software visibility are disabled.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SIP_PUBK_HASH0</ipxact:name>
          <ipxact:addressOffset>'hec</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>key_hash</ipxact:name>
            <ipxact:description>Hash digest of SiP owner's root public key for secure boot. The chiplet creator's actual root public key is embedded in the SEPROM; this digest is used to validate that public key.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SIP_UID</ipxact:name>
          <ipxact:addressOffset>'h10c</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>uid</ipxact:name>
            <ipxact:description>SiP owner's secret device unique ID. The SiP owner is responsible for SIP_UID provisioning and public identity enrollment. When read-locked, both writability and software visibility are disabled.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SYS_PUBK_HASH</ipxact:name>
          <ipxact:addressOffset>'h12c</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>key_hash</ipxact:name>
            <ipxact:description>Hash digest of system owner's root public key for secure boot.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SYS_UID</ipxact:name>
          <ipxact:addressOffset>'h14c</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>uid</ipxact:name>
            <ipxact:description>System owner's secret device unique ID. The system owner is responsible for SYS_UID provisioning and public identity enrollment. When read-locked, both writability and software visibility are disabled.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>STATUS_RPT</ipxact:name>
          <ipxact:addressOffset>'h16c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>rpt</ipxact:name>
            <ipxact:description>BOOTROM report status based on the bit. 2'b00-&gt; bootrom report status based on GPIO; 2'b01-&gt;bootrom report status;otherwise, bootrom does not report status</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>2</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>reserved</ipxact:name>
            <ipxact:description>reserved</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>30</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ROM_CTL</ipxact:name>
          <ipxact:description>Reserved.</ipxact:description>
          <ipxact:addressOffset>'h170</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>reserved</ipxact:name>
            <ipxact:description>reserved</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SYSCLK_FREQ_MHZ</ipxact:name>
          <ipxact:addressOffset>'h174</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>sysclk_freq_mhz</ipxact:name>
            <ipxact:description>Configured sysclk PLL frequency in MHz; ignored if 0. Consumed by boot ROM clock math.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>11</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Reserved</ipxact:description>
            <ipxact:bitOffset>11</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>21</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CHIPLET_PUBK_HASH0</ipxact:name>
          <ipxact:addressOffset>'h178</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>key_hash</ipxact:name>
            <ipxact:description>Chiplet owner authentication key hash digest, fused. These chiplet owner fused key hashes can be used in addition to the hashes in the ROM itself to authenticate manifests.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CHIPLET_PUBK_HASH1</ipxact:name>
          <ipxact:addressOffset>'h198</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>key_hash</ipxact:name>
            <ipxact:description>Chiplet owner authentication key hash digest, fused. These chiplet owner fused key hashes can be used in addition to the hashes in the ROM itself to authenticate manifests.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>REQUIRED_SIGNERS</ipxact:name>
          <ipxact:addressOffset>'h1b8</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>required_signers</ipxact:name>
            <ipxact:description>Owners whose signature is required to authenticate any image loadable by SEP ROM. Per owner, 1 = required, 0 = not-required; the default all-zero value requires no additional owner. [0] SiP owner, [1] system owner. The chiplet creator is the root of trust and always authenticates BL1, so it has no bit here.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>2</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>reserved</ipxact:name>
            <ipxact:description>Reserved</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>30</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>REQUIRED_ALGS</ipxact:name>
          <ipxact:addressOffset>'h1bc</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>chiplet_algs</ipxact:name>
            <ipxact:description>Per-owner required signature algorithms for chiplet. Each nibble: bit 0 = classical (ECDSA P-384 or RSA), bit 1 = post-quantum (ML-DSA), bits 3:2 reserved.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>sip_algs</ipxact:name>
            <ipxact:description>Per-owner required signature algorithms for SiP owner. bit 0 = classical, bit 1 = post-quantum (ML-DSA), bits 3:2 reserved.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>sys_algs</ipxact:name>
            <ipxact:description>Per-owner required signature algorithms for system owner. bit 0 = classical, bit 1 = post-quantum (ML-DSA), bits 3:2 reserved.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>reserved</ipxact:name>
            <ipxact:description>Reserved</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>20</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CHIPLET_PUBK_PQC_HASH0</ipxact:name>
          <ipxact:addressOffset>'h1c0</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>key_hash</ipxact:name>
            <ipxact:description>Chiplet owner ML-DSA PQC authentication key hash digest, fused. PQC counterpart of the corresponding CHIPLET_PUBK_HASH.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CHIPLET_PUBK_PQC_HASH1</ipxact:name>
          <ipxact:addressOffset>'h1e0</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>key_hash</ipxact:name>
            <ipxact:description>Chiplet owner ML-DSA PQC authentication key hash digest, fused. PQC counterpart of the corresponding CHIPLET_PUBK_HASH.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SIP_PUBK_PQC_HASH0</ipxact:name>
          <ipxact:addressOffset>'h200</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>key_hash</ipxact:name>
            <ipxact:description>Hash digest of the SiP owner's ML-DSA PQC root public key for secure boot. PQC counterpart of SIP_PUBK_HASH.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SYS_PUBK_PQC_HASH</ipxact:name>
          <ipxact:addressOffset>'h220</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>key_hash</ipxact:name>
            <ipxact:description>Hash digest of the system owner's ML-DSA PQC root public key for secure boot. PQC counterpart of SYS_PUBK_HASH.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SIP_PUBK_HASH1</ipxact:name>
          <ipxact:addressOffset>'h240</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>key_hash</ipxact:name>
            <ipxact:description>Hash digest of SiP owner's root public key for secure boot. The chiplet creator's actual root public key is embedded in the SEPROM; this digest is used to validate that public key.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SIP_PUBK_PQC_HASH1</ipxact:name>
          <ipxact:addressOffset>'h260</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>key_hash</ipxact:name>
            <ipxact:description>Hash digest of the SiP owner's ML-DSA PQC root public key for secure boot. PQC counterpart of SIP_PUBK_HASH.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEP_CHIPLET_ID</ipxact:name>
          <ipxact:addressOffset>'h280</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>id</ipxact:name>
            <ipxact:description>Per-owner public identity fuse. Personalization input for the Key Manager identity root. Being public, no read protection is required. Individually lockable via LOCKS[58:63] (slots 29-31).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEP_SIP_ID</ipxact:name>
          <ipxact:addressOffset>'h2a0</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>id</ipxact:name>
            <ipxact:description>Per-owner public identity fuse. Personalization input for the Key Manager identity root. Being public, no read protection is required. Individually lockable via LOCKS[58:63] (slots 29-31).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEP_SYS_ID</ipxact:name>
          <ipxact:addressOffset>'h2c0</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>id</ipxact:name>
            <ipxact:description>Per-owner public identity fuse. Personalization input for the Key Manager identity root. Being public, no read protection is required. Individually lockable via LOCKS[58:63] (slots 29-31).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>spare0</ipxact:name>
          <ipxact:addressOffset>'h2e0</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Spare region for future use. Individually lockable via LOCKS_SPARE (slots 32-40).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>spare1</ipxact:name>
          <ipxact:addressOffset>'h300</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Spare region for future use. Individually lockable via LOCKS_SPARE (slots 32-40).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>spare2</ipxact:name>
          <ipxact:addressOffset>'h320</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Spare region for future use. Individually lockable via LOCKS_SPARE (slots 32-40).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>spare3</ipxact:name>
          <ipxact:addressOffset>'h340</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Spare region for future use. Individually lockable via LOCKS_SPARE (slots 32-40).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>spare4</ipxact:name>
          <ipxact:addressOffset>'h360</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Spare region for future use. Individually lockable via LOCKS_SPARE (slots 32-40).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>spare5</ipxact:name>
          <ipxact:addressOffset>'h380</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Spare region for future use. Individually lockable via LOCKS_SPARE (slots 32-40).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>spare6</ipxact:name>
          <ipxact:addressOffset>'h3a0</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Spare region for future use. Individually lockable via LOCKS_SPARE (slots 32-40).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>spare7</ipxact:name>
          <ipxact:addressOffset>'h3c0</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Spare region for future use. Individually lockable via LOCKS_SPARE (slots 32-40).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>spare8</ipxact:name>
          <ipxact:addressOffset>'h3e0</ipxact:addressOffset>
          <ipxact:size>256</ipxact:size>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Spare region for future use. Individually lockable via LOCKS_SPARE (slots 32-40).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>256</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>efuse_interface_ctrl</ipxact:name>
        <ipxact:displayName>eFuse Interface Control Address Map</ipxact:displayName>
        <ipxact:description>Program and read command, address, data, status, and timeout registers for the eFuse interface.</ipxact:description>
        <ipxact:baseAddress>'h10930400</ipxact:baseAddress>
        <ipxact:range>'h24</ipxact:range>
        <ipxact:width>32</ipxact:width>
        <ipxact:register>
          <ipxact:name>EFUSE_INTERFACE_CTRL_STATUS</ipxact:name>
          <ipxact:description>eFuse interface status and error-clear register. Reports the sense-done flag and request/address error conditions, and provides write-1 strobes to clear those errors.</ipxact:description>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>efuse_sense_done</ipxact:name>
            <ipxact:description>Indicates if the eFuse state machine has completed</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>efuse_req_error</ipxact:name>
            <ipxact:description>Indicates that the eFuse was blocked because of either read or a program lock.  The error must be cleared by writing 1 to efuse_req_error_clear to this register</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>efuse_program_addr_error</ipxact:name>
            <ipxact:description>Indicates that an invalid eFuse program address was used (address exceeds the implemented eFuse size). The error must be cleared by writing 1 to efuse_program_addr_error_clear.</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>efuse_read_addr_error</ipxact:name>
            <ipxact:description>Indicates that an invalid eFuse read address was used (address exceeds the implemented eFuse size). The error must be cleared by writing 1 to efuse_read_addr_error_clear.</ipxact:description>
            <ipxact:bitOffset>6</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>efuse_req_error_clear</ipxact:name>
            <ipxact:description>Clears the blocked request error bit in efuse_ctrl_status</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>efuse_program_addr_error_clear</ipxact:name>
            <ipxact:description>Clears the program out of bounds error bit (efuse_program_addr_error) in efuse_ctrl_status</ipxact:description>
            <ipxact:bitOffset>9</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>efuse_read_addr_error_clear</ipxact:name>
            <ipxact:description>Clears the read out of bounds error bit (efuse_read_addr_error) in efuse_ctrl_status</ipxact:description>
            <ipxact:bitOffset>10</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>EFUSE_PROGRAM_CTRL</ipxact:name>
          <ipxact:description>eFuse program control and status. Configures the program data, triggers a program of the bit at EFUSE_PROGRAM_ADDR, and reports program progress and completion status.</ipxact:description>
          <ipxact:addressOffset>'h4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>efuse_data</ipxact:name>
            <ipxact:description>Data to program to eFuse.  If this bit is 0, a program request is refused: it issues no command and completes at once with program_done 1 and program_status 1</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>efuse_program_go</ipxact:name>
            <ipxact:description>When set, triggers a program to the eFuse.  A request made while program_enable is clear, efuse_data is 0, the address is out of bounds, or the bit is locked or blocked is refused: it issues no command and completes at once with program_done 1 and program_status 1</ipxact:description>
            <ipxact:bitOffset>17</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>program_busy</ipxact:name>
            <ipxact:description>When set, the program is in progress</ipxact:description>
            <ipxact:bitOffset>24</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>program_done</ipxact:name>
            <ipxact:description>When set, the program has completed, the status of which is in program_status.  Cleared when the next efuse_program_go is accepted; a refused request leaves it set and updates program_status</ipxact:description>
            <ipxact:bitOffset>25</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>program_status</ipxact:name>
            <ipxact:description>0: No Error.  1: Error. Set when efuse_program_go is refused, or the program request fails or times out.</ipxact:description>
            <ipxact:bitOffset>26</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>program_enable</ipxact:name>
            <ipxact:description>When set, enables the program request</ipxact:description>
            <ipxact:bitOffset>27</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>EFUSE_READ_CTRL</ipxact:name>
          <ipxact:description>eFuse read control and status. Triggers a read of the word at EFUSE_READ_ADDR and reports read progress and completion status.</ipxact:description>
          <ipxact:addressOffset>'h8</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>efuse_read_go</ipxact:name>
            <ipxact:description>When set, triggers a read to efuse.  A request made while read_enable is clear, the address is out of bounds, or the word is locked or blocked is refused: it issues no command and completes at once with read_done 1 and read_status 1</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>read_busy</ipxact:name>
            <ipxact:description>When set, the read is in progress</ipxact:description>
            <ipxact:bitOffset>24</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>read_done</ipxact:name>
            <ipxact:description>When set, the read has completed, the status of which is in read_status.  Cleared when the next efuse_read_go is accepted; a refused request leaves it set and updates read_status</ipxact:description>
            <ipxact:bitOffset>25</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>read_status</ipxact:name>
            <ipxact:description>0: No Error.  1: Error. Set when read_go is asserted while read is not enabled, the address is out of bounds, or the read request times out.</ipxact:description>
            <ipxact:bitOffset>26</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>read_enable</ipxact:name>
            <ipxact:description>When set, enables the read request</ipxact:description>
            <ipxact:bitOffset>28</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>EFUSE_PROGRAM_INTERFACE_READ_DATA</ipxact:name>
          <ipxact:description>Data the adopter SHIM returned with the last successful program, for example a read-back word. Held until the next successful program and not valid after an error. Hardware debug only.</ipxact:description>
          <ipxact:addressOffset>'hc</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>dout</ipxact:name>
            <ipxact:description>Program response data from the adopter SHIM; its meaning is adopter-defined.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>EFUSE_READ_INTERFACE_READ_DATA</ipxact:name>
          <ipxact:description>Read data returned through the eFuse read interface.</ipxact:description>
          <ipxact:addressOffset>'h10</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>dout</ipxact:name>
            <ipxact:description>Read Data from eFuse through READ interface.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>EFUSE_READ_REQ_TIMEOUT</ipxact:name>
          <ipxact:description>Read interface timeout configuration. Sets the number of cycles the read interface waits for a SHIM response and enables the read timeout.</ipxact:description>
          <ipxact:addressOffset>'h14</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>read_req_timeout_cycles</ipxact:name>
            <ipxact:description>Number of cycles the read interface will wait for a response from the shim. At 100MHz this can count ~= 2.5 seconds.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h800000</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>28</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>read_req_timout_enable</ipxact:name>
            <ipxact:description>Enable timeout on read interface</ipxact:description>
            <ipxact:bitOffset>28</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>EFUSE_PROGRAM_REQ_TIMEOUT</ipxact:name>
          <ipxact:description>Program interface timeout configuration. Sets the number of cycles the program interface waits for a SHIM response and enables the program timeout.</ipxact:description>
          <ipxact:addressOffset>'h18</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>program_req_timeout_cycles</ipxact:name>
            <ipxact:description>Number of cycles the program interface will wait for a response from the shim. At 100MHz this can count ~= 2.5 seconds.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h800000</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>28</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>program_req_timeout_enable</ipxact:name>
            <ipxact:description>Enable timeout on program interface.</ipxact:description>
            <ipxact:bitOffset>28</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>EFUSE_PROGRAM_ADDR</ipxact:name>
          <ipxact:description>Bit address for the next program. Set it before EFUSE_PROGRAM_CTRL.efuse_program_go.</ipxact:description>
          <ipxact:addressOffset>'h1c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>efuse_addr</ipxact:name>
            <ipxact:description>Bit address to program. Writing this register does not check the address; a program started with an address at or beyond the implemented eFuse size is not issued and sets efuse_program_addr_error.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>EFUSE_READ_ADDR</ipxact:name>
          <ipxact:description>Bit address for the next read. Set it before EFUSE_READ_CTRL.efuse_read_go.</ipxact:description>
          <ipxact:addressOffset>'h20</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>efuse_addr</ipxact:name>
            <ipxact:description>Bit address of the word to read. Writing this register does not check the address; a read started with an address at or beyond the implemented eFuse size is not issued and sets efuse_read_addr_error.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>efuse_mmr</ipxact:name>
        <ipxact:displayName>eFuse Token Registers Address Map</ipxact:displayName>
        <ipxact:description>Security-token input and match-status registers for RMA and secure-disable eFuse tokens.</ipxact:description>
        <ipxact:baseAddress>'h10930500</ipxact:baseAddress>
        <ipxact:range>'h74</ipxact:range>
        <ipxact:width>32</ipxact:width>
        <ipxact:register>
          <ipxact:name>RMA_SIP_TOKEN_I</ipxact:name>
          <ipxact:description>Software-writeable RMA token word. The assembled token is hashed and compared against the fused value to authorize lifecycle (LC) state transitions.</ipxact:description>
          <ipxact:dim>8</ipxact:dim>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>token</ipxact:name>
            <ipxact:description>Portion of writeable version of RMA_*_TOKEN, hashed, and compared with fused value to allow LC to change states.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>RMA_CHIPLET_TOKEN_I</ipxact:name>
          <ipxact:description>Software-writeable RMA token word. The assembled token is hashed and compared against the fused value to authorize lifecycle (LC) state transitions.</ipxact:description>
          <ipxact:dim>8</ipxact:dim>
          <ipxact:addressOffset>'h20</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>token</ipxact:name>
            <ipxact:description>Portion of writeable version of RMA_*_TOKEN, hashed, and compared with fused value to allow LC to change states.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEC_DISABLE_TOKEN_I</ipxact:name>
          <ipxact:description>Software-writeable security-disable token word. The assembled token is hashed and compared against the post-silicon injected value to authorize security_disable.</ipxact:description>
          <ipxact:dim>8</ipxact:dim>
          <ipxact:addressOffset>'h40</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>token</ipxact:name>
            <ipxact:description>Portion of writeable version of SEC_DISABLE_TOKEN, hashed, and compared with the post silicon injected values to allow security_disable.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>TOKEN_EOP</ipxact:name>
          <ipxact:description>Token end-of-packet control. Writing the per-token go bit signals that all token words have been written and triggers a pulse to begin token hashing.</ipxact:description>
          <ipxact:addressOffset>'h60</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>rma_sip_token_go</ipxact:name>
            <ipxact:description>Write 1 to indicate that all token data has been written; this generates a pulse to begin token hashing.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rma_chiplet_token_go</ipxact:name>
            <ipxact:description>Write 1 to indicate that all token data has been written; this generates a pulse to begin token hashing.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>secure_disable_token_go</ipxact:name>
            <ipxact:description>Write 1 to indicate that all token data has been written; this generates a pulse to begin token hashing.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>RMA_SIP_TOKEN_MATCH</ipxact:name>
          <ipxact:description>Token match status. Reports the result of the token hash comparison (match, mismatch, or error).</ipxact:description>
          <ipxact:addressOffset>'h64</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>token_match_status</ipxact:name>
            <ipxact:description>Store the status of the token match.  Match = 6'b010101, Mismatch = 6'b101010, Error = 6'b111111</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>6</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>RMA_CHIPLET_TOKEN_MATCH</ipxact:name>
          <ipxact:description>Token match status. Reports the result of the token hash comparison (match, mismatch, or error).</ipxact:description>
          <ipxact:addressOffset>'h68</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>token_match_status</ipxact:name>
            <ipxact:description>Store the status of the token match.  Match = 6'b010101, Mismatch = 6'b101010, Error = 6'b111111</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>6</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEC_DISABLE_TOKEN_MATCH</ipxact:name>
          <ipxact:description>Token match status. Reports the result of the token hash comparison (match, mismatch, or error).</ipxact:description>
          <ipxact:addressOffset>'h6c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>token_match_status</ipxact:name>
            <ipxact:description>Store the status of the token match.  Match = 6'b010101, Mismatch = 6'b101010, Error = 6'b111111</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>6</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>TOKEN_MATCH_FAULT</ipxact:name>
          <ipxact:description>Token comparator redundancy fault status. The token match logic is triple redundant and is not a majority vote: all three comparators must agree and each must drive a legal differential pair. A bit sets when the comparators for that token disagree, which may indicate a fault injection or FIB attack. The corresponding token_match_status then reads the error code 6'b111111 and an interrupt is raised to the SEP CPU. Bits are sticky until reset.</ipxact:description>
          <ipxact:addressOffset>'h70</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>rma_sip_token_fault</ipxact:name>
            <ipxact:description>A redundancy fault was detected in the RMA_SIP_TOKEN comparators.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rma_chiplet_token_fault</ipxact:name>
            <ipxact:description>A redundancy fault was detected in the RMA_CHIPLET_TOKEN comparators.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>secure_disable_token_fault</ipxact:name>
            <ipxact:description>A redundancy fault was detected in the SEC_DISABLE_TOKEN comparators.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>abr</ipxact:name>
        <ipxact:description>address maps for adams bridge register space</ipxact:description>
        <ipxact:baseAddress>'h10940000</ipxact:baseAddress>
        <ipxact:range>'hc018</ipxact:range>
        <ipxact:width>32</ipxact:width>
        <ipxact:register>
          <ipxact:name>MLDSA_NAME</ipxact:name>
          <ipxact:displayName>MLDSA component name register type definition</ipxact:displayName>
          <ipxact:description>Two 32-bit read-only registers representing of the name
of MLDSA component.</ipxact:description>
          <ipxact:dim>2</ipxact:dim>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>NAME</ipxact:name>
            <ipxact:description>Name field</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MLDSA_VERSION</ipxact:name>
          <ipxact:displayName>MLDSA component version register type definition</ipxact:displayName>
          <ipxact:description>Two 32-bit read-only registers representing of the version
of MLDSA component.</ipxact:description>
          <ipxact:dim>2</ipxact:dim>
          <ipxact:addressOffset>'h8</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>VERSION</ipxact:name>
            <ipxact:description>Version field</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MLDSA_CTRL</ipxact:name>
          <ipxact:displayName>MLDSA component control register type definition</ipxact:displayName>
          <ipxact:description>Control register to set the type of MLDSA operations.</ipxact:description>
          <ipxact:addressOffset>'h10</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>CTRL</ipxact:name>
            <ipxact:description>Control command field. This can be:
[br]            000 for NONE
[br]            001 for KEYGEN
[br]            010 for SIGNING
[br]            011 for VERIFYING
[br]            100 for KEYGEN+SIGN

[br] After each software write, hardware will erase the register</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>3</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ZEROIZE</ipxact:name>
            <ipxact:description>Zeroize all internal registers: Zeroize all internal registers and memories to avoid SCA leakage.
[br] Software write generates only a single-cycle pulse on the
hardware interface and then will be erased</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>PCR_SIGN</ipxact:name>
            <ipxact:description>Run PCR Signing flow: Run MLDSA KeyGen+Signing flow to sign PCRs.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>EXTERNAL_MU</ipxact:name>
            <ipxact:description>ExternalMu Mode</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>STREAM_MSG</ipxact:name>
            <ipxact:description>Enable streaming mode to get message for signing/verifying operation</ipxact:description>
            <ipxact:bitOffset>6</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MLDSA_STATUS</ipxact:name>
          <ipxact:displayName>MLDSA component status register type definition</ipxact:displayName>
          <ipxact:description>One 3-bit register including the following flags:
[br]bit #0: READY : ​Indicates if the core is ready to take
[br]                a control command and process the inputs.
[br]bit #1: VALID : ​Indicates if the process is done and the
[br]                result is valid.
[br]bit #2: MSG_STREAM_READY: Indicates if the core is ready
[br]                          to recieve the message in streaming mode.
[br]bit #3: ERROR: Indicates the process ended with an error</ipxact:description>
          <ipxact:addressOffset>'h14</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>READY</ipxact:name>
            <ipxact:description>Status ready bit</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>VALID</ipxact:name>
            <ipxact:description>Status valid bit</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>MSG_STREAM_READY</ipxact:name>
            <ipxact:description>The core is ready to recieve the message in streaming mode</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ERROR</ipxact:name>
            <ipxact:description>Status error bit</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ABR_ENTROPY</ipxact:name>
          <ipxact:displayName>ABR component entropy register type definition, used for MLDSA and MLKEM</ipxact:displayName>
          <ipxact:description>16 32-bit registers storing the 512-bit entropy
required for SCA countermeasures with no change on the outputs.
The entropy can be any 512-bit value in [0 : 2^512-1].</ipxact:description>
          <ipxact:dim>16</ipxact:dim>
          <ipxact:addressOffset>'h18</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>ENTROPY</ipxact:name>
            <ipxact:description>Input entropy field</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MLDSA_SEED</ipxact:name>
          <ipxact:displayName>MLDSA component seed register type definition</ipxact:displayName>
          <ipxact:description>8 32-bit registers storing the 256-bit seed for keygen.
The seed can be any 256-bit value in [0 : 2^256-1].</ipxact:description>
          <ipxact:dim>8</ipxact:dim>
          <ipxact:addressOffset>'h58</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SEED</ipxact:name>
            <ipxact:description>Input seed field</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MLDSA_SIGN_RND</ipxact:name>
          <ipxact:displayName>MLDSA component sign_rnd register type definition</ipxact:displayName>
          <ipxact:description>8 32-bit registers storing the 256-bit sign_rnd for signing.
The sign_rnd can be any 256-bit value in [0 : 2^256-1].
sign_rnd should be all zero for deterministic variant.</ipxact:description>
          <ipxact:dim>8</ipxact:dim>
          <ipxact:addressOffset>'h78</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SIGN_RND</ipxact:name>
            <ipxact:description>Input sign_rnd field</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MLDSA_MSG</ipxact:name>
          <ipxact:displayName>MLDSA component message register type definition</ipxact:displayName>
          <ipxact:description>16 32-bit registers storing the message.
The message can be a fixed size of 512-bit value in [0 : 2^512-1].</ipxact:description>
          <ipxact:dim>16</ipxact:dim>
          <ipxact:addressOffset>'h98</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>MSG</ipxact:name>
            <ipxact:description>Input message field</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MLDSA_VERIFY_RES</ipxact:name>
          <ipxact:displayName>MLDSA component verify result register type definition</ipxact:displayName>
          <ipxact:description>16 32-bit registers storing the result of verifying operation.
If this register is equal to the first part of the given signature, i.e. c~,
the signature is verified.</ipxact:description>
          <ipxact:dim>16</ipxact:dim>
          <ipxact:addressOffset>'hd8</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>VERIFY_RES</ipxact:name>
            <ipxact:description>Output verify result field</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MLDSA_EXTERNAL_MU</ipxact:name>
          <ipxact:displayName>MLDSA component external_mu register type definition</ipxact:displayName>
          <ipxact:description>16 32-bit registers storing the external_mu.
The external_mu can be any 512-bit value in [0 : 2^512-1].</ipxact:description>
          <ipxact:dim>16</ipxact:dim>
          <ipxact:addressOffset>'h118</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>EXTERNAL_MU</ipxact:name>
            <ipxact:description>Input message field</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MLDSA_MSG_STROBE</ipxact:name>
          <ipxact:displayName>MLDSA component msg strobe register type definition</ipxact:displayName>
          <ipxact:description>Byte enable strobe for each 32 bits of message.
[br] Must be set to 4'b1111 before streaming message, after observing stream_msg_rdy.
[br] Set to 1 for each valid byte in the last msg data, starting from LSB.
[br] Valid values are 4'b0000, 4'b0001, 4'b0011, 4'b0111, and 4'b1111
[br] A 32 bit aligned msg must write this to 4'h0 and write to msg input once.</ipxact:description>
          <ipxact:addressOffset>'h158</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>STROBE</ipxact:name>
            <ipxact:description>Input message strobe</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'hf</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MLDSA_CTX_CONFIG</ipxact:name>
          <ipxact:displayName>MLDSA component Input Context Config register type definition</ipxact:displayName>
          <ipxact:description>Registers defining the size of the context.
The context is an optional byte-string.</ipxact:description>
          <ipxact:addressOffset>'h15c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>CTX_SIZE</ipxact:name>
            <ipxact:description>Context Byte size field</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MLDSA_CTX</ipxact:name>
          <ipxact:displayName>MLDSA component context register type definition</ipxact:displayName>
          <ipxact:description>up tp 255 bytes registers storing the context.</ipxact:description>
          <ipxact:dim>64</ipxact:dim>
          <ipxact:addressOffset>'h160</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>CTX</ipxact:name>
            <ipxact:description>Input context field</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>kv_mldsa_seed_rd_ctrl</ipxact:name>
          <ipxact:displayName>Key Vault Read Control Register</ipxact:displayName>
          <ipxact:description>Controls the Key Vault read access for this engine</ipxact:description>
          <ipxact:addressOffset>'h8000</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>read_en</ipxact:name>
            <ipxact:description>Indicates that the read data is to come from the key vault.
Setting this bit to 1 initiates copying of data from the key vault.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>read_entry</ipxact:name>
            <ipxact:description>Key Vault entry to retrieve the read data from for the engine</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>pcr_hash_extend</ipxact:name>
            <ipxact:description>Requested entry is a PCR. This is used only for SHA to hash extend, it's NOP in all other engines</ipxact:description>
            <ipxact:bitOffset>6</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Reserved field</ipxact:description>
            <ipxact:bitOffset>7</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>25</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>kv_mldsa_seed_rd_status</ipxact:name>
          <ipxact:displayName>Key Vault Status Register</ipxact:displayName>
          <ipxact:description>Reports the Key Vault flow status for this engine</ipxact:description>
          <ipxact:addressOffset>'h8004</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>READY</ipxact:name>
            <ipxact:description>Key Vault control is ready for use</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>VALID</ipxact:name>
            <ipxact:description>Key Vault flow is done</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ERROR</ipxact:name>
            <ipxact:displayName>Key Vault Error</ipxact:displayName>
            <ipxact:description>Indicates the error status of a key vault flow</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
            <ipxact:enumeratedValues>
              <ipxact:enumeratedValue>
                <ipxact:name>SUCCESS</ipxact:name>
                <ipxact:description>Key Vault flow was successful</ipxact:description>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>KV_READ_FAIL</ipxact:name>
                <ipxact:description>Key Vault Read flow failed</ipxact:description>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>KV_WRITE_FAIL</ipxact:name>
                <ipxact:description>Key Vault Write flow failed</ipxact:description>
                <ipxact:value>'h2</ipxact:value>
              </ipxact:enumeratedValue>
            </ipxact:enumeratedValues>
          </ipxact:field>
        </ipxact:register>
        <ipxact:registerFile>
          <ipxact:name>intr_block_rf</ipxact:name>
          <ipxact:displayName>Interrupt Register Block</ipxact:displayName>
          <ipxact:description>Set of registers to implement interrupt functionality for ABR</ipxact:description>
          <ipxact:addressOffset>'h8100</ipxact:addressOffset>
          <ipxact:range>'h208</ipxact:range>
          <ipxact:register>
            <ipxact:name>global_intr_en_r</ipxact:name>
            <ipxact:displayName>Per-Type Interrupt Enable Register</ipxact:displayName>
            <ipxact:description>Dedicated register with one bit for each event type that may produce an interrupt.</ipxact:description>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>32</ipxact:size>
            <ipxact:field>
              <ipxact:name>error_en</ipxact:name>
              <ipxact:description>Global enable bit for all events of type 'Error'</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>notif_en</ipxact:name>
              <ipxact:description>Global enable bit for all events of type 'Notification'</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>error_intr_en_r</ipxact:name>
            <ipxact:displayName>Per-Event Interrupt Enable Register</ipxact:displayName>
            <ipxact:description>Dedicated register with one bit for each event that may produce an interrupt.</ipxact:description>
            <ipxact:addressOffset>'h4</ipxact:addressOffset>
            <ipxact:size>32</ipxact:size>
            <ipxact:field>
              <ipxact:name>error_internal_en</ipxact:name>
              <ipxact:description>Enable bit for Internal Errors</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>notif_intr_en_r</ipxact:name>
            <ipxact:displayName>Per-Event Interrupt Enable Register</ipxact:displayName>
            <ipxact:description>Dedicated register with one bit for each event that may produce an interrupt.</ipxact:description>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>32</ipxact:size>
            <ipxact:field>
              <ipxact:name>notif_cmd_done_en</ipxact:name>
              <ipxact:description>Enable bit for Command Done</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>error_global_intr_r</ipxact:name>
            <ipxact:displayName>Interrupt Status Aggregation Register type definition</ipxact:displayName>
            <ipxact:description>Single bit indicating occurrence of any interrupt event
of a given type. E.g. Notifications and Errors may drive
to two separate interrupt registers. There may be
multiple sources of Notifications or Errors that are
aggregated into a single interrupt pin for that
respective type. That pin feeds through this register
in order to apply a global enablement of that interrupt
event type.
Nonsticky assertion.</ipxact:description>
            <ipxact:addressOffset>'hc</ipxact:addressOffset>
            <ipxact:size>32</ipxact:size>
            <ipxact:field>
              <ipxact:name>agg_sts</ipxact:name>
              <ipxact:description>Interrupt Event Aggregation status bit</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>notif_global_intr_r</ipxact:name>
            <ipxact:displayName>Interrupt Status Aggregation Register type definition</ipxact:displayName>
            <ipxact:description>Single bit indicating occurrence of any interrupt event
of a given type. E.g. Notifications and Errors may drive
to two separate interrupt registers. There may be
multiple sources of Notifications or Errors that are
aggregated into a single interrupt pin for that
respective type. That pin feeds through this register
in order to apply a global enablement of that interrupt
event type.
Nonsticky assertion.</ipxact:description>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>32</ipxact:size>
            <ipxact:field>
              <ipxact:name>agg_sts</ipxact:name>
              <ipxact:description>Interrupt Event Aggregation status bit</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>error_internal_intr_r</ipxact:name>
            <ipxact:displayName>Interrupt Status Register type definition</ipxact:displayName>
            <ipxact:description>Single bit indicating occurrence of each interrupt event.
Sticky, level assertion, write-1-to-clear.</ipxact:description>
            <ipxact:addressOffset>'h14</ipxact:addressOffset>
            <ipxact:size>32</ipxact:size>
            <ipxact:field>
              <ipxact:name>error_internal_sts</ipxact:name>
              <ipxact:description>Internal Errors status bit</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>notif_internal_intr_r</ipxact:name>
            <ipxact:displayName>Interrupt Status Register type definition</ipxact:displayName>
            <ipxact:description>Single bit indicating occurrence of each interrupt event.
Sticky, level assertion, write-1-to-clear.</ipxact:description>
            <ipxact:addressOffset>'h18</ipxact:addressOffset>
            <ipxact:size>32</ipxact:size>
            <ipxact:field>
              <ipxact:name>notif_cmd_done_sts</ipxact:name>
              <ipxact:description>Command Done status bit</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>error_intr_trig_r</ipxact:name>
            <ipxact:displayName>Interrupt Trigger Register type definition</ipxact:displayName>
            <ipxact:description>Single bit for each interrupt event allows SW to manually
trigger occurrence of that event. Upon SW write, the trigger bit
will pulse for 1 cycle then clear to 0. The pulse on the
trigger register bit results in the corresponding interrupt
status bit being set to 1.</ipxact:description>
            <ipxact:addressOffset>'h1c</ipxact:addressOffset>
            <ipxact:size>32</ipxact:size>
            <ipxact:field>
              <ipxact:name>error_internal_trig</ipxact:name>
              <ipxact:description>Internal Errors trigger bit</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>notif_intr_trig_r</ipxact:name>
            <ipxact:displayName>Interrupt Trigger Register type definition</ipxact:displayName>
            <ipxact:description>Single bit for each interrupt event allows SW to manually
trigger occurrence of that event. Upon SW write, the trigger bit
will pulse for 1 cycle then clear to 0. The pulse on the
trigger register bit results in the corresponding interrupt
status bit being set to 1.</ipxact:description>
            <ipxact:addressOffset>'h20</ipxact:addressOffset>
            <ipxact:size>32</ipxact:size>
            <ipxact:field>
              <ipxact:name>notif_cmd_done_trig</ipxact:name>
              <ipxact:description>Command Done trigger bit</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>error_internal_intr_count_r</ipxact:name>
            <ipxact:displayName>Interrupt Event Counter</ipxact:displayName>
            <ipxact:description>Provides statistics about the number of events that have
occurred.
Will not overflow ('incrsaturate').</ipxact:description>
            <ipxact:addressOffset>'h100</ipxact:addressOffset>
            <ipxact:size>32</ipxact:size>
            <ipxact:field>
              <ipxact:name>cnt</ipxact:name>
              <ipxact:description>Count field</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>32</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>notif_cmd_done_intr_count_r</ipxact:name>
            <ipxact:displayName>Interrupt Event Counter</ipxact:displayName>
            <ipxact:description>Provides statistics about the number of events that have
occurred.
Will not overflow ('incrsaturate').</ipxact:description>
            <ipxact:addressOffset>'h180</ipxact:addressOffset>
            <ipxact:size>32</ipxact:size>
            <ipxact:field>
              <ipxact:name>cnt</ipxact:name>
              <ipxact:description>Count field</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>32</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>error_internal_intr_count_incr_r</ipxact:name>
            <ipxact:displayName>Interrupt Event Count Incrementor</ipxact:displayName>
            <ipxact:description>Trigger the event counter to increment based on observing
the rising edge of an interrupt event input from the
Hardware. The same input signal that causes an interrupt
event to be set (sticky) also causes this signal to pulse
for 1 clock cycle, resulting in the event counter
incrementing by 1 for every interrupt event.
This is implemented as a down-counter (1-bit) that will
decrement immediately on being set - resulting in a pulse</ipxact:description>
            <ipxact:addressOffset>'h200</ipxact:addressOffset>
            <ipxact:size>32</ipxact:size>
            <ipxact:field>
              <ipxact:name>pulse</ipxact:name>
              <ipxact:description>Pulse mirrors interrupt event occurrence</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>notif_cmd_done_intr_count_incr_r</ipxact:name>
            <ipxact:displayName>Interrupt Event Count Incrementor</ipxact:displayName>
            <ipxact:description>Trigger the event counter to increment based on observing
the rising edge of an interrupt event input from the
Hardware. The same input signal that causes an interrupt
event to be set (sticky) also causes this signal to pulse
for 1 clock cycle, resulting in the event counter
incrementing by 1 for every interrupt event.
This is implemented as a down-counter (1-bit) that will
decrement immediately on being set - resulting in a pulse</ipxact:description>
            <ipxact:addressOffset>'h204</ipxact:addressOffset>
            <ipxact:size>32</ipxact:size>
            <ipxact:field>
              <ipxact:name>pulse</ipxact:name>
              <ipxact:description>Pulse mirrors interrupt event occurrence</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
        <ipxact:register>
          <ipxact:name>MLKEM_NAME</ipxact:name>
          <ipxact:displayName>MLKEM component name register type definition</ipxact:displayName>
          <ipxact:description>Two 32-bit read-only registers representing of the name
of MLKEM component.</ipxact:description>
          <ipxact:dim>2</ipxact:dim>
          <ipxact:addressOffset>'h9000</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>NAME</ipxact:name>
            <ipxact:description>Name field</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MLKEM_VERSION</ipxact:name>
          <ipxact:displayName>MLKEM component version register type definition</ipxact:displayName>
          <ipxact:description>Two 32-bit read-only registers representing of the version
of MLKEM component.</ipxact:description>
          <ipxact:dim>2</ipxact:dim>
          <ipxact:addressOffset>'h9008</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>VERSION</ipxact:name>
            <ipxact:description>Version field</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MLKEM_CTRL</ipxact:name>
          <ipxact:displayName>MLKEM component control register type definition</ipxact:displayName>
          <ipxact:description>Control register to set the type of MLKEM operations.</ipxact:description>
          <ipxact:addressOffset>'h9010</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>CTRL</ipxact:name>
            <ipxact:description>Control command field. This can be:
[br]            000 for NONE
[br]            001 for KEYGEN
[br]            010 for ENCAPS
[br]            011 for DECAPS
[br]            100 for KEYGEN+DECAPS

[br] After each software write, hardware will erase the register</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>3</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ZEROIZE</ipxact:name>
            <ipxact:description>Zeroize all internal registers: Zeroize all internal registers and memories to avoid SCA leakage.
[br] Software write generates only a single-cycle pulse on the
[br] hardware interface and then will be erased</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MLKEM_STATUS</ipxact:name>
          <ipxact:displayName>MLKEM component status register type definition</ipxact:displayName>
          <ipxact:description>One 3-bit register including the following flags:
[br]bit #0: READY : ​Indicates if the core is ready to take
[br]                a control command and process the inputs.
[br]bit #1: VALID : ​Indicates if the process is done and the
[br]                result is valid.
[br]bit #2: ERROR : ​Indicates the process ended in an error.</ipxact:description>
          <ipxact:addressOffset>'h9014</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>READY</ipxact:name>
            <ipxact:description>Status ready bit</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>VALID</ipxact:name>
            <ipxact:description>Status valid bit</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ERROR</ipxact:name>
            <ipxact:description>Status error bit</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MLKEM_SEED_D</ipxact:name>
          <ipxact:displayName>MLKEM component seed register type definition</ipxact:displayName>
          <ipxact:description>8 32-bit registers storing the 256-bit seed for keygen.
The seed can be any 256-bit value in [0 : 2^256-1].</ipxact:description>
          <ipxact:dim>8</ipxact:dim>
          <ipxact:addressOffset>'h9018</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SEED</ipxact:name>
            <ipxact:description>Input seed d field</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MLKEM_SEED_Z</ipxact:name>
          <ipxact:displayName>MLKEM component seed register type definition</ipxact:displayName>
          <ipxact:description>8 32-bit registers storing the 256-bit seed for keygen.
The seed can be any 256-bit value in [0 : 2^256-1].</ipxact:description>
          <ipxact:dim>8</ipxact:dim>
          <ipxact:addressOffset>'h9038</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>SEED</ipxact:name>
            <ipxact:description>Input seed z field</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>MLKEM_SHARED_KEY</ipxact:name>
          <ipxact:displayName>MLKEM component shared key register type definition</ipxact:displayName>
          <ipxact:description>8 32-bit registers storing the shared key.</ipxact:description>
          <ipxact:dim>8</ipxact:dim>
          <ipxact:addressOffset>'h9058</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>KEY</ipxact:name>
            <ipxact:description>Output shared key</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>kv_mlkem_seed_rd_ctrl</ipxact:name>
          <ipxact:displayName>Key Vault Read Control Register</ipxact:displayName>
          <ipxact:description>Controls the Key Vault read access for this engine</ipxact:description>
          <ipxact:addressOffset>'hc000</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>read_en</ipxact:name>
            <ipxact:description>Indicates that the read data is to come from the key vault.
Setting this bit to 1 initiates copying of data from the key vault.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>read_entry</ipxact:name>
            <ipxact:description>Key Vault entry to retrieve the read data from for the engine</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>pcr_hash_extend</ipxact:name>
            <ipxact:description>Requested entry is a PCR. This is used only for SHA to hash extend, it's NOP in all other engines</ipxact:description>
            <ipxact:bitOffset>6</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Reserved field</ipxact:description>
            <ipxact:bitOffset>7</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>25</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>kv_mlkem_seed_rd_status</ipxact:name>
          <ipxact:displayName>Key Vault Status Register</ipxact:displayName>
          <ipxact:description>Reports the Key Vault flow status for this engine</ipxact:description>
          <ipxact:addressOffset>'hc004</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>READY</ipxact:name>
            <ipxact:description>Key Vault control is ready for use</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>VALID</ipxact:name>
            <ipxact:description>Key Vault flow is done</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ERROR</ipxact:name>
            <ipxact:displayName>Key Vault Error</ipxact:displayName>
            <ipxact:description>Indicates the error status of a key vault flow</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
            <ipxact:enumeratedValues>
              <ipxact:enumeratedValue>
                <ipxact:name>SUCCESS</ipxact:name>
                <ipxact:description>Key Vault flow was successful</ipxact:description>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>KV_READ_FAIL</ipxact:name>
                <ipxact:description>Key Vault Read flow failed</ipxact:description>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>KV_WRITE_FAIL</ipxact:name>
                <ipxact:description>Key Vault Write flow failed</ipxact:description>
                <ipxact:value>'h2</ipxact:value>
              </ipxact:enumeratedValue>
            </ipxact:enumeratedValues>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>kv_mlkem_msg_rd_ctrl</ipxact:name>
          <ipxact:displayName>Key Vault Read Control Register</ipxact:displayName>
          <ipxact:description>Controls the Key Vault read access for this engine</ipxact:description>
          <ipxact:addressOffset>'hc008</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>read_en</ipxact:name>
            <ipxact:description>Indicates that the read data is to come from the key vault.
Setting this bit to 1 initiates copying of data from the key vault.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>read_entry</ipxact:name>
            <ipxact:description>Key Vault entry to retrieve the read data from for the engine</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>pcr_hash_extend</ipxact:name>
            <ipxact:description>Requested entry is a PCR. This is used only for SHA to hash extend, it's NOP in all other engines</ipxact:description>
            <ipxact:bitOffset>6</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Reserved field</ipxact:description>
            <ipxact:bitOffset>7</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>25</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>kv_mlkem_msg_rd_status</ipxact:name>
          <ipxact:displayName>Key Vault Status Register</ipxact:displayName>
          <ipxact:description>Reports the Key Vault flow status for this engine</ipxact:description>
          <ipxact:addressOffset>'hc00c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>READY</ipxact:name>
            <ipxact:description>Key Vault control is ready for use</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>VALID</ipxact:name>
            <ipxact:description>Key Vault flow is done</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ERROR</ipxact:name>
            <ipxact:displayName>Key Vault Error</ipxact:displayName>
            <ipxact:description>Indicates the error status of a key vault flow</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
            <ipxact:enumeratedValues>
              <ipxact:enumeratedValue>
                <ipxact:name>SUCCESS</ipxact:name>
                <ipxact:description>Key Vault flow was successful</ipxact:description>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>KV_READ_FAIL</ipxact:name>
                <ipxact:description>Key Vault Read flow failed</ipxact:description>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>KV_WRITE_FAIL</ipxact:name>
                <ipxact:description>Key Vault Write flow failed</ipxact:description>
                <ipxact:value>'h2</ipxact:value>
              </ipxact:enumeratedValue>
            </ipxact:enumeratedValues>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>kv_mlkem_sharedkey_wr_ctrl</ipxact:name>
          <ipxact:displayName>Key Vault Write Control Register</ipxact:displayName>
          <ipxact:description>Controls the Key Vault write access for this engine</ipxact:description>
          <ipxact:addressOffset>'hc010</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>write_en</ipxact:name>
            <ipxact:description>Indicates that the result is to be stored in the key vault.
Setting this bit to 1 will copy the result to the keyvault when it is ready.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>write_entry</ipxact:name>
            <ipxact:description>Key Vault entry to store the result</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>5</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>hmac_key_dest_valid</ipxact:name>
            <ipxact:description>HMAC KEY is a valid destination</ipxact:description>
            <ipxact:bitOffset>6</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>hmac_block_dest_valid</ipxact:name>
            <ipxact:description>HMAC BLOCK is a valid destination</ipxact:description>
            <ipxact:bitOffset>7</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>mldsa_seed_dest_valid</ipxact:name>
            <ipxact:description>MLDSA_SEED is a valid destination</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ecc_pkey_dest_valid</ipxact:name>
            <ipxact:description>ECC PKEY is a valid destination</ipxact:description>
            <ipxact:bitOffset>9</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ecc_seed_dest_valid</ipxact:name>
            <ipxact:description>ECC SEED is a valid destination</ipxact:description>
            <ipxact:bitOffset>10</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>aes_key_dest_valid</ipxact:name>
            <ipxact:description>AES KEY is a valid destination</ipxact:description>
            <ipxact:bitOffset>11</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>mlkem_seed_dest_valid</ipxact:name>
            <ipxact:description>MLKEM SEED is a valid destination</ipxact:description>
            <ipxact:bitOffset>12</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>mlkem_msg_dest_valid</ipxact:name>
            <ipxact:description>MLKEM MSG is a valid destination</ipxact:description>
            <ipxact:bitOffset>13</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>dma_data_dest_valid</ipxact:name>
            <ipxact:description>AXI DMA data is a valid destination</ipxact:description>
            <ipxact:bitOffset>14</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Reserved field</ipxact:description>
            <ipxact:bitOffset>15</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>17</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>kv_mlkem_sharedkey_wr_status</ipxact:name>
          <ipxact:displayName>Key Vault Status Register</ipxact:displayName>
          <ipxact:description>Reports the Key Vault flow status for this engine</ipxact:description>
          <ipxact:addressOffset>'hc014</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>READY</ipxact:name>
            <ipxact:description>Key Vault control is ready for use</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>VALID</ipxact:name>
            <ipxact:description>Key Vault flow is done</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ERROR</ipxact:name>
            <ipxact:displayName>Key Vault Error</ipxact:displayName>
            <ipxact:description>Indicates the error status of a key vault flow</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
            <ipxact:enumeratedValues>
              <ipxact:enumeratedValue>
                <ipxact:name>SUCCESS</ipxact:name>
                <ipxact:description>Key Vault flow was successful</ipxact:description>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>KV_READ_FAIL</ipxact:name>
                <ipxact:description>Key Vault Read flow failed</ipxact:description>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:enumeratedValue>
              <ipxact:enumeratedValue>
                <ipxact:name>KV_WRITE_FAIL</ipxact:name>
                <ipxact:description>Key Vault Write flow failed</ipxact:description>
                <ipxact:value>'h2</ipxact:value>
              </ipxact:enumeratedValue>
            </ipxact:enumeratedValues>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>entropy_pool</ipxact:name>
        <ipxact:displayName>SEP Entropy Pool</ipxact:displayName>
        <ipxact:description>Read-only entropy pool FIFO; DATA reads drain conditioned entropy supplied by the native EDN, and writes return SLVERR.</ipxact:description>
        <ipxact:baseAddress>'h10950000</ipxact:baseAddress>
        <ipxact:range>'h18</ipxact:range>
        <ipxact:width>64</ipxact:width>
        <ipxact:register>
          <ipxact:name>STATUS</ipxact:name>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>fifo_level</ipxact:name>
            <ipxact:description>Current number of available 64-bit entropy words</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>6</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>pool_low</ipxact:name>
            <ipxact:description>The pool occupancy is below the configured low watermark</ipxact:description>
            <ipxact:bitOffset>6</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fill_stall</ipxact:name>
            <ipxact:description>The EDN fill request exceeded the configured stall threshold</ipxact:description>
            <ipxact:bitOffset>7</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>pool_error</ipxact:name>
            <ipxact:description>The pool detected a FIFO integrity error</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>IRQ_CAUSE</ipxact:name>
          <ipxact:addressOffset>'h8</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>pool_low</ipxact:name>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fill_stall</ipxact:name>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>pool_error</ipxact:name>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>DATA</ipxact:name>
          <ipxact:addressOffset>'h10</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>entropy</ipxact:name>
            <ipxact:description>Pops one conditioned entropy word; an empty pool returns SLVERR</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>64</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>axil_mailbox</ipxact:name>
        <ipxact:displayName>SEP AXI-Lite Mailbox Wrapper Address Map</ipxact:displayName>
        <ipxact:description>SEP-side wrapper instantiating the AXI-Lite mailbox pairs.
Each outbound_mailbox_N / inbound_mailbox_N pair is the two apertures of one
bidirectional mailbox and shares a single pair of FIFOs: data written through
WRITE_DATA in one aperture is what READ_DATA in the other aperture returns.
The outbound/inbound naming reflects intended use, not an access restriction.</ipxact:description>
        <ipxact:baseAddress>'h10a00000</ipxact:baseAddress>
        <ipxact:range>'h7850</ipxact:range>
        <ipxact:width>64</ipxact:width>
        <ipxact:registerFile>
          <ipxact:name>outbound_mailbox_0</ipxact:name>
          <ipxact:displayName>AXI-Lite Mailbox Address Map</ipxact:displayName>
          <ipxact:description>Register interface for a single AXI-Lite mailbox: data FIFOs, level and status flags, and interrupt controls.</ipxact:description>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:range>'h50</ipxact:range>
          <ipxact:register>
            <ipxact:name>WRITE_DATA</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>write_data</ipxact:name>
              <ipxact:description>Write data to mailbox fifo. Any write pushes one entry, irrespective of WSTRB,
including a write with no byte lanes enabled; byte lanes whose strobe is 0 are
pushed as 0.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>READ_DATA</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register pops one whole 64-bit entry
from the mailbox fifo, and only the byte lanes it requests are returned. A 32-bit
read of either half therefore discards the other half of the entry; read this
register with 64-bit accesses. A read while the fifo is empty returns
0x0000_0000_FEED_DEAD with an error response.</ipxact:description>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_data</ipxact:name>
              <ipxact:description>Read data from mailbox fifo</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>modify</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>empty</ipxact:name>
              <ipxact:description>0: Data is available to read, 1: Data is not available to read</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h1</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>full</ipxact:name>
              <ipxact:description>0: Space is available to write, 1: Space is not available to write</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_level_above_thresh</ipxact:name>
              <ipxact:description>If set, write fifo level is higher than threshold set in WIRQT</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>read_level_above_thresh</ipxact:name>
              <ipxact:description>If set, read fifo level is higher than threshold set in RIRQT</ipxact:description>
              <ipxact:bitOffset>3</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>ERROR_FLAGS</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register clears every flag in it. The
flags are only returned in the lower 32 bits, so a 32-bit read of the upper half
returns 0 and still clears them; read this register with 64-bit accesses or at its
lower half.</ipxact:description>
            <ipxact:addressOffset>'h18</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_error</ipxact:name>
              <ipxact:description>Attempted read from an empty mailbox</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_error</ipxact:name>
              <ipxact:description>Attempted write to a full mailbox</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>WIRQT</ipxact:name>
            <ipxact:addressOffset>'h20</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wirqt</ipxact:name>
              <ipxact:description>When the usage pointer of the FIFO connected to the W channel exceeds this value, a write threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the write FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>RIRQT</ipxact:name>
            <ipxact:addressOffset>'h28</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>rirqt</ipxact:name>
              <ipxact:description>When the fill pointer of the FIFO connected to the R channel exceeds this value, a read threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the read FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQS</ipxact:name>
            <ipxact:description>This register is used to read and clear interrupt requests, regardless of IRQEN register and whether the interrupt is enabled or disabled.</ipxact:description>
            <ipxact:addressOffset>'h30</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in write mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in read mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Error on mailbox access
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQEN</ipxact:name>
            <ipxact:description>This register is used to enable and disable which interrupts are sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h38</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: Write threshold IRQ disabled
[1]: Write threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: Read threshold IRQ disabled
[1]: Read threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: Error IRQ disabled
[1]: Error IRQ enabled</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQP</ipxact:name>
            <ipxact:description>This register is used to read the current status of the interrupts sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h40</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: No write threshold IRQ pending
[1]: Write threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: No read threshold IRQ pending
[1]: Read threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: No error IRQ pending
[1]: Error IRQ pending</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>CTRL</ipxact:name>
            <ipxact:addressOffset>'h48</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wflush</ipxact:name>
              <ipxact:description>Flush the write FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rflush</ipxact:name>
              <ipxact:description>Flush the read FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted; a word the peer pushes in that cycle
is discarded.</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
        <ipxact:registerFile>
          <ipxact:name>inbound_mailbox_0</ipxact:name>
          <ipxact:displayName>AXI-Lite Mailbox Address Map</ipxact:displayName>
          <ipxact:description>Register interface for a single AXI-Lite mailbox: data FIFOs, level and status flags, and interrupt controls.</ipxact:description>
          <ipxact:addressOffset>'h800</ipxact:addressOffset>
          <ipxact:range>'h50</ipxact:range>
          <ipxact:register>
            <ipxact:name>WRITE_DATA</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>write_data</ipxact:name>
              <ipxact:description>Write data to mailbox fifo. Any write pushes one entry, irrespective of WSTRB,
including a write with no byte lanes enabled; byte lanes whose strobe is 0 are
pushed as 0.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>READ_DATA</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register pops one whole 64-bit entry
from the mailbox fifo, and only the byte lanes it requests are returned. A 32-bit
read of either half therefore discards the other half of the entry; read this
register with 64-bit accesses. A read while the fifo is empty returns
0x0000_0000_FEED_DEAD with an error response.</ipxact:description>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_data</ipxact:name>
              <ipxact:description>Read data from mailbox fifo</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>modify</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>empty</ipxact:name>
              <ipxact:description>0: Data is available to read, 1: Data is not available to read</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h1</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>full</ipxact:name>
              <ipxact:description>0: Space is available to write, 1: Space is not available to write</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_level_above_thresh</ipxact:name>
              <ipxact:description>If set, write fifo level is higher than threshold set in WIRQT</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>read_level_above_thresh</ipxact:name>
              <ipxact:description>If set, read fifo level is higher than threshold set in RIRQT</ipxact:description>
              <ipxact:bitOffset>3</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>ERROR_FLAGS</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register clears every flag in it. The
flags are only returned in the lower 32 bits, so a 32-bit read of the upper half
returns 0 and still clears them; read this register with 64-bit accesses or at its
lower half.</ipxact:description>
            <ipxact:addressOffset>'h18</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_error</ipxact:name>
              <ipxact:description>Attempted read from an empty mailbox</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_error</ipxact:name>
              <ipxact:description>Attempted write to a full mailbox</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>WIRQT</ipxact:name>
            <ipxact:addressOffset>'h20</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wirqt</ipxact:name>
              <ipxact:description>When the usage pointer of the FIFO connected to the W channel exceeds this value, a write threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the write FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>RIRQT</ipxact:name>
            <ipxact:addressOffset>'h28</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>rirqt</ipxact:name>
              <ipxact:description>When the fill pointer of the FIFO connected to the R channel exceeds this value, a read threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the read FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQS</ipxact:name>
            <ipxact:description>This register is used to read and clear interrupt requests, regardless of IRQEN register and whether the interrupt is enabled or disabled.</ipxact:description>
            <ipxact:addressOffset>'h30</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in write mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in read mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Error on mailbox access
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQEN</ipxact:name>
            <ipxact:description>This register is used to enable and disable which interrupts are sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h38</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: Write threshold IRQ disabled
[1]: Write threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: Read threshold IRQ disabled
[1]: Read threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: Error IRQ disabled
[1]: Error IRQ enabled</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQP</ipxact:name>
            <ipxact:description>This register is used to read the current status of the interrupts sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h40</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: No write threshold IRQ pending
[1]: Write threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: No read threshold IRQ pending
[1]: Read threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: No error IRQ pending
[1]: Error IRQ pending</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>CTRL</ipxact:name>
            <ipxact:addressOffset>'h48</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wflush</ipxact:name>
              <ipxact:description>Flush the write FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rflush</ipxact:name>
              <ipxact:description>Flush the read FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted; a word the peer pushes in that cycle
is discarded.</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
        <ipxact:registerFile>
          <ipxact:name>outbound_mailbox_1</ipxact:name>
          <ipxact:displayName>AXI-Lite Mailbox Address Map</ipxact:displayName>
          <ipxact:description>Register interface for a single AXI-Lite mailbox: data FIFOs, level and status flags, and interrupt controls.</ipxact:description>
          <ipxact:addressOffset>'h1000</ipxact:addressOffset>
          <ipxact:range>'h50</ipxact:range>
          <ipxact:register>
            <ipxact:name>WRITE_DATA</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>write_data</ipxact:name>
              <ipxact:description>Write data to mailbox fifo. Any write pushes one entry, irrespective of WSTRB,
including a write with no byte lanes enabled; byte lanes whose strobe is 0 are
pushed as 0.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>READ_DATA</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register pops one whole 64-bit entry
from the mailbox fifo, and only the byte lanes it requests are returned. A 32-bit
read of either half therefore discards the other half of the entry; read this
register with 64-bit accesses. A read while the fifo is empty returns
0x0000_0000_FEED_DEAD with an error response.</ipxact:description>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_data</ipxact:name>
              <ipxact:description>Read data from mailbox fifo</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>modify</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>empty</ipxact:name>
              <ipxact:description>0: Data is available to read, 1: Data is not available to read</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h1</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>full</ipxact:name>
              <ipxact:description>0: Space is available to write, 1: Space is not available to write</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_level_above_thresh</ipxact:name>
              <ipxact:description>If set, write fifo level is higher than threshold set in WIRQT</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>read_level_above_thresh</ipxact:name>
              <ipxact:description>If set, read fifo level is higher than threshold set in RIRQT</ipxact:description>
              <ipxact:bitOffset>3</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>ERROR_FLAGS</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register clears every flag in it. The
flags are only returned in the lower 32 bits, so a 32-bit read of the upper half
returns 0 and still clears them; read this register with 64-bit accesses or at its
lower half.</ipxact:description>
            <ipxact:addressOffset>'h18</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_error</ipxact:name>
              <ipxact:description>Attempted read from an empty mailbox</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_error</ipxact:name>
              <ipxact:description>Attempted write to a full mailbox</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>WIRQT</ipxact:name>
            <ipxact:addressOffset>'h20</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wirqt</ipxact:name>
              <ipxact:description>When the usage pointer of the FIFO connected to the W channel exceeds this value, a write threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the write FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>RIRQT</ipxact:name>
            <ipxact:addressOffset>'h28</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>rirqt</ipxact:name>
              <ipxact:description>When the fill pointer of the FIFO connected to the R channel exceeds this value, a read threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the read FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQS</ipxact:name>
            <ipxact:description>This register is used to read and clear interrupt requests, regardless of IRQEN register and whether the interrupt is enabled or disabled.</ipxact:description>
            <ipxact:addressOffset>'h30</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in write mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in read mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Error on mailbox access
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQEN</ipxact:name>
            <ipxact:description>This register is used to enable and disable which interrupts are sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h38</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: Write threshold IRQ disabled
[1]: Write threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: Read threshold IRQ disabled
[1]: Read threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: Error IRQ disabled
[1]: Error IRQ enabled</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQP</ipxact:name>
            <ipxact:description>This register is used to read the current status of the interrupts sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h40</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: No write threshold IRQ pending
[1]: Write threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: No read threshold IRQ pending
[1]: Read threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: No error IRQ pending
[1]: Error IRQ pending</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>CTRL</ipxact:name>
            <ipxact:addressOffset>'h48</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wflush</ipxact:name>
              <ipxact:description>Flush the write FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rflush</ipxact:name>
              <ipxact:description>Flush the read FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted; a word the peer pushes in that cycle
is discarded.</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
        <ipxact:registerFile>
          <ipxact:name>inbound_mailbox_1</ipxact:name>
          <ipxact:displayName>AXI-Lite Mailbox Address Map</ipxact:displayName>
          <ipxact:description>Register interface for a single AXI-Lite mailbox: data FIFOs, level and status flags, and interrupt controls.</ipxact:description>
          <ipxact:addressOffset>'h1800</ipxact:addressOffset>
          <ipxact:range>'h50</ipxact:range>
          <ipxact:register>
            <ipxact:name>WRITE_DATA</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>write_data</ipxact:name>
              <ipxact:description>Write data to mailbox fifo. Any write pushes one entry, irrespective of WSTRB,
including a write with no byte lanes enabled; byte lanes whose strobe is 0 are
pushed as 0.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>READ_DATA</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register pops one whole 64-bit entry
from the mailbox fifo, and only the byte lanes it requests are returned. A 32-bit
read of either half therefore discards the other half of the entry; read this
register with 64-bit accesses. A read while the fifo is empty returns
0x0000_0000_FEED_DEAD with an error response.</ipxact:description>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_data</ipxact:name>
              <ipxact:description>Read data from mailbox fifo</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>modify</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>empty</ipxact:name>
              <ipxact:description>0: Data is available to read, 1: Data is not available to read</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h1</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>full</ipxact:name>
              <ipxact:description>0: Space is available to write, 1: Space is not available to write</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_level_above_thresh</ipxact:name>
              <ipxact:description>If set, write fifo level is higher than threshold set in WIRQT</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>read_level_above_thresh</ipxact:name>
              <ipxact:description>If set, read fifo level is higher than threshold set in RIRQT</ipxact:description>
              <ipxact:bitOffset>3</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>ERROR_FLAGS</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register clears every flag in it. The
flags are only returned in the lower 32 bits, so a 32-bit read of the upper half
returns 0 and still clears them; read this register with 64-bit accesses or at its
lower half.</ipxact:description>
            <ipxact:addressOffset>'h18</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_error</ipxact:name>
              <ipxact:description>Attempted read from an empty mailbox</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_error</ipxact:name>
              <ipxact:description>Attempted write to a full mailbox</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>WIRQT</ipxact:name>
            <ipxact:addressOffset>'h20</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wirqt</ipxact:name>
              <ipxact:description>When the usage pointer of the FIFO connected to the W channel exceeds this value, a write threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the write FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>RIRQT</ipxact:name>
            <ipxact:addressOffset>'h28</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>rirqt</ipxact:name>
              <ipxact:description>When the fill pointer of the FIFO connected to the R channel exceeds this value, a read threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the read FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQS</ipxact:name>
            <ipxact:description>This register is used to read and clear interrupt requests, regardless of IRQEN register and whether the interrupt is enabled or disabled.</ipxact:description>
            <ipxact:addressOffset>'h30</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in write mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in read mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Error on mailbox access
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQEN</ipxact:name>
            <ipxact:description>This register is used to enable and disable which interrupts are sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h38</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: Write threshold IRQ disabled
[1]: Write threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: Read threshold IRQ disabled
[1]: Read threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: Error IRQ disabled
[1]: Error IRQ enabled</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQP</ipxact:name>
            <ipxact:description>This register is used to read the current status of the interrupts sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h40</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: No write threshold IRQ pending
[1]: Write threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: No read threshold IRQ pending
[1]: Read threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: No error IRQ pending
[1]: Error IRQ pending</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>CTRL</ipxact:name>
            <ipxact:addressOffset>'h48</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wflush</ipxact:name>
              <ipxact:description>Flush the write FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rflush</ipxact:name>
              <ipxact:description>Flush the read FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted; a word the peer pushes in that cycle
is discarded.</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
        <ipxact:registerFile>
          <ipxact:name>outbound_mailbox_2</ipxact:name>
          <ipxact:displayName>AXI-Lite Mailbox Address Map</ipxact:displayName>
          <ipxact:description>Register interface for a single AXI-Lite mailbox: data FIFOs, level and status flags, and interrupt controls.</ipxact:description>
          <ipxact:addressOffset>'h2000</ipxact:addressOffset>
          <ipxact:range>'h50</ipxact:range>
          <ipxact:register>
            <ipxact:name>WRITE_DATA</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>write_data</ipxact:name>
              <ipxact:description>Write data to mailbox fifo. Any write pushes one entry, irrespective of WSTRB,
including a write with no byte lanes enabled; byte lanes whose strobe is 0 are
pushed as 0.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>READ_DATA</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register pops one whole 64-bit entry
from the mailbox fifo, and only the byte lanes it requests are returned. A 32-bit
read of either half therefore discards the other half of the entry; read this
register with 64-bit accesses. A read while the fifo is empty returns
0x0000_0000_FEED_DEAD with an error response.</ipxact:description>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_data</ipxact:name>
              <ipxact:description>Read data from mailbox fifo</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>modify</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>empty</ipxact:name>
              <ipxact:description>0: Data is available to read, 1: Data is not available to read</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h1</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>full</ipxact:name>
              <ipxact:description>0: Space is available to write, 1: Space is not available to write</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_level_above_thresh</ipxact:name>
              <ipxact:description>If set, write fifo level is higher than threshold set in WIRQT</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>read_level_above_thresh</ipxact:name>
              <ipxact:description>If set, read fifo level is higher than threshold set in RIRQT</ipxact:description>
              <ipxact:bitOffset>3</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>ERROR_FLAGS</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register clears every flag in it. The
flags are only returned in the lower 32 bits, so a 32-bit read of the upper half
returns 0 and still clears them; read this register with 64-bit accesses or at its
lower half.</ipxact:description>
            <ipxact:addressOffset>'h18</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_error</ipxact:name>
              <ipxact:description>Attempted read from an empty mailbox</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_error</ipxact:name>
              <ipxact:description>Attempted write to a full mailbox</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>WIRQT</ipxact:name>
            <ipxact:addressOffset>'h20</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wirqt</ipxact:name>
              <ipxact:description>When the usage pointer of the FIFO connected to the W channel exceeds this value, a write threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the write FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>RIRQT</ipxact:name>
            <ipxact:addressOffset>'h28</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>rirqt</ipxact:name>
              <ipxact:description>When the fill pointer of the FIFO connected to the R channel exceeds this value, a read threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the read FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQS</ipxact:name>
            <ipxact:description>This register is used to read and clear interrupt requests, regardless of IRQEN register and whether the interrupt is enabled or disabled.</ipxact:description>
            <ipxact:addressOffset>'h30</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in write mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in read mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Error on mailbox access
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQEN</ipxact:name>
            <ipxact:description>This register is used to enable and disable which interrupts are sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h38</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: Write threshold IRQ disabled
[1]: Write threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: Read threshold IRQ disabled
[1]: Read threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: Error IRQ disabled
[1]: Error IRQ enabled</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQP</ipxact:name>
            <ipxact:description>This register is used to read the current status of the interrupts sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h40</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: No write threshold IRQ pending
[1]: Write threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: No read threshold IRQ pending
[1]: Read threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: No error IRQ pending
[1]: Error IRQ pending</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>CTRL</ipxact:name>
            <ipxact:addressOffset>'h48</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wflush</ipxact:name>
              <ipxact:description>Flush the write FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rflush</ipxact:name>
              <ipxact:description>Flush the read FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted; a word the peer pushes in that cycle
is discarded.</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
        <ipxact:registerFile>
          <ipxact:name>inbound_mailbox_2</ipxact:name>
          <ipxact:displayName>AXI-Lite Mailbox Address Map</ipxact:displayName>
          <ipxact:description>Register interface for a single AXI-Lite mailbox: data FIFOs, level and status flags, and interrupt controls.</ipxact:description>
          <ipxact:addressOffset>'h2800</ipxact:addressOffset>
          <ipxact:range>'h50</ipxact:range>
          <ipxact:register>
            <ipxact:name>WRITE_DATA</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>write_data</ipxact:name>
              <ipxact:description>Write data to mailbox fifo. Any write pushes one entry, irrespective of WSTRB,
including a write with no byte lanes enabled; byte lanes whose strobe is 0 are
pushed as 0.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>READ_DATA</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register pops one whole 64-bit entry
from the mailbox fifo, and only the byte lanes it requests are returned. A 32-bit
read of either half therefore discards the other half of the entry; read this
register with 64-bit accesses. A read while the fifo is empty returns
0x0000_0000_FEED_DEAD with an error response.</ipxact:description>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_data</ipxact:name>
              <ipxact:description>Read data from mailbox fifo</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>modify</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>empty</ipxact:name>
              <ipxact:description>0: Data is available to read, 1: Data is not available to read</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h1</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>full</ipxact:name>
              <ipxact:description>0: Space is available to write, 1: Space is not available to write</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_level_above_thresh</ipxact:name>
              <ipxact:description>If set, write fifo level is higher than threshold set in WIRQT</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>read_level_above_thresh</ipxact:name>
              <ipxact:description>If set, read fifo level is higher than threshold set in RIRQT</ipxact:description>
              <ipxact:bitOffset>3</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>ERROR_FLAGS</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register clears every flag in it. The
flags are only returned in the lower 32 bits, so a 32-bit read of the upper half
returns 0 and still clears them; read this register with 64-bit accesses or at its
lower half.</ipxact:description>
            <ipxact:addressOffset>'h18</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_error</ipxact:name>
              <ipxact:description>Attempted read from an empty mailbox</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_error</ipxact:name>
              <ipxact:description>Attempted write to a full mailbox</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>WIRQT</ipxact:name>
            <ipxact:addressOffset>'h20</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wirqt</ipxact:name>
              <ipxact:description>When the usage pointer of the FIFO connected to the W channel exceeds this value, a write threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the write FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>RIRQT</ipxact:name>
            <ipxact:addressOffset>'h28</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>rirqt</ipxact:name>
              <ipxact:description>When the fill pointer of the FIFO connected to the R channel exceeds this value, a read threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the read FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQS</ipxact:name>
            <ipxact:description>This register is used to read and clear interrupt requests, regardless of IRQEN register and whether the interrupt is enabled or disabled.</ipxact:description>
            <ipxact:addressOffset>'h30</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in write mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in read mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Error on mailbox access
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQEN</ipxact:name>
            <ipxact:description>This register is used to enable and disable which interrupts are sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h38</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: Write threshold IRQ disabled
[1]: Write threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: Read threshold IRQ disabled
[1]: Read threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: Error IRQ disabled
[1]: Error IRQ enabled</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQP</ipxact:name>
            <ipxact:description>This register is used to read the current status of the interrupts sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h40</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: No write threshold IRQ pending
[1]: Write threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: No read threshold IRQ pending
[1]: Read threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: No error IRQ pending
[1]: Error IRQ pending</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>CTRL</ipxact:name>
            <ipxact:addressOffset>'h48</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wflush</ipxact:name>
              <ipxact:description>Flush the write FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rflush</ipxact:name>
              <ipxact:description>Flush the read FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted; a word the peer pushes in that cycle
is discarded.</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
        <ipxact:registerFile>
          <ipxact:name>outbound_mailbox_3</ipxact:name>
          <ipxact:displayName>AXI-Lite Mailbox Address Map</ipxact:displayName>
          <ipxact:description>Register interface for a single AXI-Lite mailbox: data FIFOs, level and status flags, and interrupt controls.</ipxact:description>
          <ipxact:addressOffset>'h3000</ipxact:addressOffset>
          <ipxact:range>'h50</ipxact:range>
          <ipxact:register>
            <ipxact:name>WRITE_DATA</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>write_data</ipxact:name>
              <ipxact:description>Write data to mailbox fifo. Any write pushes one entry, irrespective of WSTRB,
including a write with no byte lanes enabled; byte lanes whose strobe is 0 are
pushed as 0.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>READ_DATA</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register pops one whole 64-bit entry
from the mailbox fifo, and only the byte lanes it requests are returned. A 32-bit
read of either half therefore discards the other half of the entry; read this
register with 64-bit accesses. A read while the fifo is empty returns
0x0000_0000_FEED_DEAD with an error response.</ipxact:description>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_data</ipxact:name>
              <ipxact:description>Read data from mailbox fifo</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>modify</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>empty</ipxact:name>
              <ipxact:description>0: Data is available to read, 1: Data is not available to read</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h1</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>full</ipxact:name>
              <ipxact:description>0: Space is available to write, 1: Space is not available to write</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_level_above_thresh</ipxact:name>
              <ipxact:description>If set, write fifo level is higher than threshold set in WIRQT</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>read_level_above_thresh</ipxact:name>
              <ipxact:description>If set, read fifo level is higher than threshold set in RIRQT</ipxact:description>
              <ipxact:bitOffset>3</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>ERROR_FLAGS</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register clears every flag in it. The
flags are only returned in the lower 32 bits, so a 32-bit read of the upper half
returns 0 and still clears them; read this register with 64-bit accesses or at its
lower half.</ipxact:description>
            <ipxact:addressOffset>'h18</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_error</ipxact:name>
              <ipxact:description>Attempted read from an empty mailbox</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_error</ipxact:name>
              <ipxact:description>Attempted write to a full mailbox</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>WIRQT</ipxact:name>
            <ipxact:addressOffset>'h20</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wirqt</ipxact:name>
              <ipxact:description>When the usage pointer of the FIFO connected to the W channel exceeds this value, a write threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the write FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>RIRQT</ipxact:name>
            <ipxact:addressOffset>'h28</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>rirqt</ipxact:name>
              <ipxact:description>When the fill pointer of the FIFO connected to the R channel exceeds this value, a read threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the read FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQS</ipxact:name>
            <ipxact:description>This register is used to read and clear interrupt requests, regardless of IRQEN register and whether the interrupt is enabled or disabled.</ipxact:description>
            <ipxact:addressOffset>'h30</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in write mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in read mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Error on mailbox access
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQEN</ipxact:name>
            <ipxact:description>This register is used to enable and disable which interrupts are sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h38</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: Write threshold IRQ disabled
[1]: Write threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: Read threshold IRQ disabled
[1]: Read threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: Error IRQ disabled
[1]: Error IRQ enabled</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQP</ipxact:name>
            <ipxact:description>This register is used to read the current status of the interrupts sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h40</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: No write threshold IRQ pending
[1]: Write threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: No read threshold IRQ pending
[1]: Read threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: No error IRQ pending
[1]: Error IRQ pending</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>CTRL</ipxact:name>
            <ipxact:addressOffset>'h48</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wflush</ipxact:name>
              <ipxact:description>Flush the write FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rflush</ipxact:name>
              <ipxact:description>Flush the read FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted; a word the peer pushes in that cycle
is discarded.</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
        <ipxact:registerFile>
          <ipxact:name>inbound_mailbox_3</ipxact:name>
          <ipxact:displayName>AXI-Lite Mailbox Address Map</ipxact:displayName>
          <ipxact:description>Register interface for a single AXI-Lite mailbox: data FIFOs, level and status flags, and interrupt controls.</ipxact:description>
          <ipxact:addressOffset>'h3800</ipxact:addressOffset>
          <ipxact:range>'h50</ipxact:range>
          <ipxact:register>
            <ipxact:name>WRITE_DATA</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>write_data</ipxact:name>
              <ipxact:description>Write data to mailbox fifo. Any write pushes one entry, irrespective of WSTRB,
including a write with no byte lanes enabled; byte lanes whose strobe is 0 are
pushed as 0.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>READ_DATA</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register pops one whole 64-bit entry
from the mailbox fifo, and only the byte lanes it requests are returned. A 32-bit
read of either half therefore discards the other half of the entry; read this
register with 64-bit accesses. A read while the fifo is empty returns
0x0000_0000_FEED_DEAD with an error response.</ipxact:description>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_data</ipxact:name>
              <ipxact:description>Read data from mailbox fifo</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>modify</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>empty</ipxact:name>
              <ipxact:description>0: Data is available to read, 1: Data is not available to read</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h1</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>full</ipxact:name>
              <ipxact:description>0: Space is available to write, 1: Space is not available to write</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_level_above_thresh</ipxact:name>
              <ipxact:description>If set, write fifo level is higher than threshold set in WIRQT</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>read_level_above_thresh</ipxact:name>
              <ipxact:description>If set, read fifo level is higher than threshold set in RIRQT</ipxact:description>
              <ipxact:bitOffset>3</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>ERROR_FLAGS</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register clears every flag in it. The
flags are only returned in the lower 32 bits, so a 32-bit read of the upper half
returns 0 and still clears them; read this register with 64-bit accesses or at its
lower half.</ipxact:description>
            <ipxact:addressOffset>'h18</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_error</ipxact:name>
              <ipxact:description>Attempted read from an empty mailbox</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_error</ipxact:name>
              <ipxact:description>Attempted write to a full mailbox</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>WIRQT</ipxact:name>
            <ipxact:addressOffset>'h20</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wirqt</ipxact:name>
              <ipxact:description>When the usage pointer of the FIFO connected to the W channel exceeds this value, a write threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the write FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>RIRQT</ipxact:name>
            <ipxact:addressOffset>'h28</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>rirqt</ipxact:name>
              <ipxact:description>When the fill pointer of the FIFO connected to the R channel exceeds this value, a read threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the read FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQS</ipxact:name>
            <ipxact:description>This register is used to read and clear interrupt requests, regardless of IRQEN register and whether the interrupt is enabled or disabled.</ipxact:description>
            <ipxact:addressOffset>'h30</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in write mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in read mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Error on mailbox access
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQEN</ipxact:name>
            <ipxact:description>This register is used to enable and disable which interrupts are sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h38</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: Write threshold IRQ disabled
[1]: Write threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: Read threshold IRQ disabled
[1]: Read threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: Error IRQ disabled
[1]: Error IRQ enabled</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQP</ipxact:name>
            <ipxact:description>This register is used to read the current status of the interrupts sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h40</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: No write threshold IRQ pending
[1]: Write threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: No read threshold IRQ pending
[1]: Read threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: No error IRQ pending
[1]: Error IRQ pending</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>CTRL</ipxact:name>
            <ipxact:addressOffset>'h48</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wflush</ipxact:name>
              <ipxact:description>Flush the write FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rflush</ipxact:name>
              <ipxact:description>Flush the read FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted; a word the peer pushes in that cycle
is discarded.</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
        <ipxact:registerFile>
          <ipxact:name>outbound_mailbox_4</ipxact:name>
          <ipxact:displayName>AXI-Lite Mailbox Address Map</ipxact:displayName>
          <ipxact:description>Register interface for a single AXI-Lite mailbox: data FIFOs, level and status flags, and interrupt controls.</ipxact:description>
          <ipxact:addressOffset>'h4000</ipxact:addressOffset>
          <ipxact:range>'h50</ipxact:range>
          <ipxact:register>
            <ipxact:name>WRITE_DATA</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>write_data</ipxact:name>
              <ipxact:description>Write data to mailbox fifo. Any write pushes one entry, irrespective of WSTRB,
including a write with no byte lanes enabled; byte lanes whose strobe is 0 are
pushed as 0.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>READ_DATA</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register pops one whole 64-bit entry
from the mailbox fifo, and only the byte lanes it requests are returned. A 32-bit
read of either half therefore discards the other half of the entry; read this
register with 64-bit accesses. A read while the fifo is empty returns
0x0000_0000_FEED_DEAD with an error response.</ipxact:description>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_data</ipxact:name>
              <ipxact:description>Read data from mailbox fifo</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>modify</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>empty</ipxact:name>
              <ipxact:description>0: Data is available to read, 1: Data is not available to read</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h1</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>full</ipxact:name>
              <ipxact:description>0: Space is available to write, 1: Space is not available to write</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_level_above_thresh</ipxact:name>
              <ipxact:description>If set, write fifo level is higher than threshold set in WIRQT</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>read_level_above_thresh</ipxact:name>
              <ipxact:description>If set, read fifo level is higher than threshold set in RIRQT</ipxact:description>
              <ipxact:bitOffset>3</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>ERROR_FLAGS</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register clears every flag in it. The
flags are only returned in the lower 32 bits, so a 32-bit read of the upper half
returns 0 and still clears them; read this register with 64-bit accesses or at its
lower half.</ipxact:description>
            <ipxact:addressOffset>'h18</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_error</ipxact:name>
              <ipxact:description>Attempted read from an empty mailbox</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_error</ipxact:name>
              <ipxact:description>Attempted write to a full mailbox</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>WIRQT</ipxact:name>
            <ipxact:addressOffset>'h20</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wirqt</ipxact:name>
              <ipxact:description>When the usage pointer of the FIFO connected to the W channel exceeds this value, a write threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the write FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>RIRQT</ipxact:name>
            <ipxact:addressOffset>'h28</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>rirqt</ipxact:name>
              <ipxact:description>When the fill pointer of the FIFO connected to the R channel exceeds this value, a read threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the read FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQS</ipxact:name>
            <ipxact:description>This register is used to read and clear interrupt requests, regardless of IRQEN register and whether the interrupt is enabled or disabled.</ipxact:description>
            <ipxact:addressOffset>'h30</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in write mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in read mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Error on mailbox access
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQEN</ipxact:name>
            <ipxact:description>This register is used to enable and disable which interrupts are sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h38</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: Write threshold IRQ disabled
[1]: Write threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: Read threshold IRQ disabled
[1]: Read threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: Error IRQ disabled
[1]: Error IRQ enabled</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQP</ipxact:name>
            <ipxact:description>This register is used to read the current status of the interrupts sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h40</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: No write threshold IRQ pending
[1]: Write threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: No read threshold IRQ pending
[1]: Read threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: No error IRQ pending
[1]: Error IRQ pending</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>CTRL</ipxact:name>
            <ipxact:addressOffset>'h48</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wflush</ipxact:name>
              <ipxact:description>Flush the write FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rflush</ipxact:name>
              <ipxact:description>Flush the read FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted; a word the peer pushes in that cycle
is discarded.</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
        <ipxact:registerFile>
          <ipxact:name>inbound_mailbox_4</ipxact:name>
          <ipxact:displayName>AXI-Lite Mailbox Address Map</ipxact:displayName>
          <ipxact:description>Register interface for a single AXI-Lite mailbox: data FIFOs, level and status flags, and interrupt controls.</ipxact:description>
          <ipxact:addressOffset>'h4800</ipxact:addressOffset>
          <ipxact:range>'h50</ipxact:range>
          <ipxact:register>
            <ipxact:name>WRITE_DATA</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>write_data</ipxact:name>
              <ipxact:description>Write data to mailbox fifo. Any write pushes one entry, irrespective of WSTRB,
including a write with no byte lanes enabled; byte lanes whose strobe is 0 are
pushed as 0.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>READ_DATA</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register pops one whole 64-bit entry
from the mailbox fifo, and only the byte lanes it requests are returned. A 32-bit
read of either half therefore discards the other half of the entry; read this
register with 64-bit accesses. A read while the fifo is empty returns
0x0000_0000_FEED_DEAD with an error response.</ipxact:description>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_data</ipxact:name>
              <ipxact:description>Read data from mailbox fifo</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>modify</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>empty</ipxact:name>
              <ipxact:description>0: Data is available to read, 1: Data is not available to read</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h1</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>full</ipxact:name>
              <ipxact:description>0: Space is available to write, 1: Space is not available to write</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_level_above_thresh</ipxact:name>
              <ipxact:description>If set, write fifo level is higher than threshold set in WIRQT</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>read_level_above_thresh</ipxact:name>
              <ipxact:description>If set, read fifo level is higher than threshold set in RIRQT</ipxact:description>
              <ipxact:bitOffset>3</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>ERROR_FLAGS</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register clears every flag in it. The
flags are only returned in the lower 32 bits, so a 32-bit read of the upper half
returns 0 and still clears them; read this register with 64-bit accesses or at its
lower half.</ipxact:description>
            <ipxact:addressOffset>'h18</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_error</ipxact:name>
              <ipxact:description>Attempted read from an empty mailbox</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_error</ipxact:name>
              <ipxact:description>Attempted write to a full mailbox</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>WIRQT</ipxact:name>
            <ipxact:addressOffset>'h20</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wirqt</ipxact:name>
              <ipxact:description>When the usage pointer of the FIFO connected to the W channel exceeds this value, a write threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the write FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>RIRQT</ipxact:name>
            <ipxact:addressOffset>'h28</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>rirqt</ipxact:name>
              <ipxact:description>When the fill pointer of the FIFO connected to the R channel exceeds this value, a read threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the read FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQS</ipxact:name>
            <ipxact:description>This register is used to read and clear interrupt requests, regardless of IRQEN register and whether the interrupt is enabled or disabled.</ipxact:description>
            <ipxact:addressOffset>'h30</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in write mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in read mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Error on mailbox access
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQEN</ipxact:name>
            <ipxact:description>This register is used to enable and disable which interrupts are sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h38</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: Write threshold IRQ disabled
[1]: Write threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: Read threshold IRQ disabled
[1]: Read threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: Error IRQ disabled
[1]: Error IRQ enabled</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQP</ipxact:name>
            <ipxact:description>This register is used to read the current status of the interrupts sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h40</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: No write threshold IRQ pending
[1]: Write threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: No read threshold IRQ pending
[1]: Read threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: No error IRQ pending
[1]: Error IRQ pending</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>CTRL</ipxact:name>
            <ipxact:addressOffset>'h48</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wflush</ipxact:name>
              <ipxact:description>Flush the write FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rflush</ipxact:name>
              <ipxact:description>Flush the read FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted; a word the peer pushes in that cycle
is discarded.</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
        <ipxact:registerFile>
          <ipxact:name>outbound_mailbox_5</ipxact:name>
          <ipxact:displayName>AXI-Lite Mailbox Address Map</ipxact:displayName>
          <ipxact:description>Register interface for a single AXI-Lite mailbox: data FIFOs, level and status flags, and interrupt controls.</ipxact:description>
          <ipxact:addressOffset>'h5000</ipxact:addressOffset>
          <ipxact:range>'h50</ipxact:range>
          <ipxact:register>
            <ipxact:name>WRITE_DATA</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>write_data</ipxact:name>
              <ipxact:description>Write data to mailbox fifo. Any write pushes one entry, irrespective of WSTRB,
including a write with no byte lanes enabled; byte lanes whose strobe is 0 are
pushed as 0.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>READ_DATA</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register pops one whole 64-bit entry
from the mailbox fifo, and only the byte lanes it requests are returned. A 32-bit
read of either half therefore discards the other half of the entry; read this
register with 64-bit accesses. A read while the fifo is empty returns
0x0000_0000_FEED_DEAD with an error response.</ipxact:description>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_data</ipxact:name>
              <ipxact:description>Read data from mailbox fifo</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>modify</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>empty</ipxact:name>
              <ipxact:description>0: Data is available to read, 1: Data is not available to read</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h1</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>full</ipxact:name>
              <ipxact:description>0: Space is available to write, 1: Space is not available to write</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_level_above_thresh</ipxact:name>
              <ipxact:description>If set, write fifo level is higher than threshold set in WIRQT</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>read_level_above_thresh</ipxact:name>
              <ipxact:description>If set, read fifo level is higher than threshold set in RIRQT</ipxact:description>
              <ipxact:bitOffset>3</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>ERROR_FLAGS</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register clears every flag in it. The
flags are only returned in the lower 32 bits, so a 32-bit read of the upper half
returns 0 and still clears them; read this register with 64-bit accesses or at its
lower half.</ipxact:description>
            <ipxact:addressOffset>'h18</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_error</ipxact:name>
              <ipxact:description>Attempted read from an empty mailbox</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_error</ipxact:name>
              <ipxact:description>Attempted write to a full mailbox</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>WIRQT</ipxact:name>
            <ipxact:addressOffset>'h20</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wirqt</ipxact:name>
              <ipxact:description>When the usage pointer of the FIFO connected to the W channel exceeds this value, a write threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the write FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>RIRQT</ipxact:name>
            <ipxact:addressOffset>'h28</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>rirqt</ipxact:name>
              <ipxact:description>When the fill pointer of the FIFO connected to the R channel exceeds this value, a read threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the read FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQS</ipxact:name>
            <ipxact:description>This register is used to read and clear interrupt requests, regardless of IRQEN register and whether the interrupt is enabled or disabled.</ipxact:description>
            <ipxact:addressOffset>'h30</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in write mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in read mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Error on mailbox access
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQEN</ipxact:name>
            <ipxact:description>This register is used to enable and disable which interrupts are sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h38</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: Write threshold IRQ disabled
[1]: Write threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: Read threshold IRQ disabled
[1]: Read threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: Error IRQ disabled
[1]: Error IRQ enabled</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQP</ipxact:name>
            <ipxact:description>This register is used to read the current status of the interrupts sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h40</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: No write threshold IRQ pending
[1]: Write threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: No read threshold IRQ pending
[1]: Read threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: No error IRQ pending
[1]: Error IRQ pending</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>CTRL</ipxact:name>
            <ipxact:addressOffset>'h48</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wflush</ipxact:name>
              <ipxact:description>Flush the write FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rflush</ipxact:name>
              <ipxact:description>Flush the read FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted; a word the peer pushes in that cycle
is discarded.</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
        <ipxact:registerFile>
          <ipxact:name>inbound_mailbox_5</ipxact:name>
          <ipxact:displayName>AXI-Lite Mailbox Address Map</ipxact:displayName>
          <ipxact:description>Register interface for a single AXI-Lite mailbox: data FIFOs, level and status flags, and interrupt controls.</ipxact:description>
          <ipxact:addressOffset>'h5800</ipxact:addressOffset>
          <ipxact:range>'h50</ipxact:range>
          <ipxact:register>
            <ipxact:name>WRITE_DATA</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>write_data</ipxact:name>
              <ipxact:description>Write data to mailbox fifo. Any write pushes one entry, irrespective of WSTRB,
including a write with no byte lanes enabled; byte lanes whose strobe is 0 are
pushed as 0.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>READ_DATA</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register pops one whole 64-bit entry
from the mailbox fifo, and only the byte lanes it requests are returned. A 32-bit
read of either half therefore discards the other half of the entry; read this
register with 64-bit accesses. A read while the fifo is empty returns
0x0000_0000_FEED_DEAD with an error response.</ipxact:description>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_data</ipxact:name>
              <ipxact:description>Read data from mailbox fifo</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>modify</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>empty</ipxact:name>
              <ipxact:description>0: Data is available to read, 1: Data is not available to read</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h1</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>full</ipxact:name>
              <ipxact:description>0: Space is available to write, 1: Space is not available to write</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_level_above_thresh</ipxact:name>
              <ipxact:description>If set, write fifo level is higher than threshold set in WIRQT</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>read_level_above_thresh</ipxact:name>
              <ipxact:description>If set, read fifo level is higher than threshold set in RIRQT</ipxact:description>
              <ipxact:bitOffset>3</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>ERROR_FLAGS</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register clears every flag in it. The
flags are only returned in the lower 32 bits, so a 32-bit read of the upper half
returns 0 and still clears them; read this register with 64-bit accesses or at its
lower half.</ipxact:description>
            <ipxact:addressOffset>'h18</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_error</ipxact:name>
              <ipxact:description>Attempted read from an empty mailbox</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_error</ipxact:name>
              <ipxact:description>Attempted write to a full mailbox</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>WIRQT</ipxact:name>
            <ipxact:addressOffset>'h20</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wirqt</ipxact:name>
              <ipxact:description>When the usage pointer of the FIFO connected to the W channel exceeds this value, a write threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the write FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>RIRQT</ipxact:name>
            <ipxact:addressOffset>'h28</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>rirqt</ipxact:name>
              <ipxact:description>When the fill pointer of the FIFO connected to the R channel exceeds this value, a read threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the read FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQS</ipxact:name>
            <ipxact:description>This register is used to read and clear interrupt requests, regardless of IRQEN register and whether the interrupt is enabled or disabled.</ipxact:description>
            <ipxact:addressOffset>'h30</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in write mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in read mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Error on mailbox access
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQEN</ipxact:name>
            <ipxact:description>This register is used to enable and disable which interrupts are sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h38</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: Write threshold IRQ disabled
[1]: Write threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: Read threshold IRQ disabled
[1]: Read threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: Error IRQ disabled
[1]: Error IRQ enabled</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQP</ipxact:name>
            <ipxact:description>This register is used to read the current status of the interrupts sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h40</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: No write threshold IRQ pending
[1]: Write threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: No read threshold IRQ pending
[1]: Read threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: No error IRQ pending
[1]: Error IRQ pending</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>CTRL</ipxact:name>
            <ipxact:addressOffset>'h48</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wflush</ipxact:name>
              <ipxact:description>Flush the write FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rflush</ipxact:name>
              <ipxact:description>Flush the read FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted; a word the peer pushes in that cycle
is discarded.</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
        <ipxact:registerFile>
          <ipxact:name>outbound_mailbox_6</ipxact:name>
          <ipxact:displayName>AXI-Lite Mailbox Address Map</ipxact:displayName>
          <ipxact:description>Register interface for a single AXI-Lite mailbox: data FIFOs, level and status flags, and interrupt controls.</ipxact:description>
          <ipxact:addressOffset>'h6000</ipxact:addressOffset>
          <ipxact:range>'h50</ipxact:range>
          <ipxact:register>
            <ipxact:name>WRITE_DATA</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>write_data</ipxact:name>
              <ipxact:description>Write data to mailbox fifo. Any write pushes one entry, irrespective of WSTRB,
including a write with no byte lanes enabled; byte lanes whose strobe is 0 are
pushed as 0.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>READ_DATA</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register pops one whole 64-bit entry
from the mailbox fifo, and only the byte lanes it requests are returned. A 32-bit
read of either half therefore discards the other half of the entry; read this
register with 64-bit accesses. A read while the fifo is empty returns
0x0000_0000_FEED_DEAD with an error response.</ipxact:description>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_data</ipxact:name>
              <ipxact:description>Read data from mailbox fifo</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>modify</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>empty</ipxact:name>
              <ipxact:description>0: Data is available to read, 1: Data is not available to read</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h1</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>full</ipxact:name>
              <ipxact:description>0: Space is available to write, 1: Space is not available to write</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_level_above_thresh</ipxact:name>
              <ipxact:description>If set, write fifo level is higher than threshold set in WIRQT</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>read_level_above_thresh</ipxact:name>
              <ipxact:description>If set, read fifo level is higher than threshold set in RIRQT</ipxact:description>
              <ipxact:bitOffset>3</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>ERROR_FLAGS</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register clears every flag in it. The
flags are only returned in the lower 32 bits, so a 32-bit read of the upper half
returns 0 and still clears them; read this register with 64-bit accesses or at its
lower half.</ipxact:description>
            <ipxact:addressOffset>'h18</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_error</ipxact:name>
              <ipxact:description>Attempted read from an empty mailbox</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_error</ipxact:name>
              <ipxact:description>Attempted write to a full mailbox</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>WIRQT</ipxact:name>
            <ipxact:addressOffset>'h20</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wirqt</ipxact:name>
              <ipxact:description>When the usage pointer of the FIFO connected to the W channel exceeds this value, a write threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the write FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>RIRQT</ipxact:name>
            <ipxact:addressOffset>'h28</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>rirqt</ipxact:name>
              <ipxact:description>When the fill pointer of the FIFO connected to the R channel exceeds this value, a read threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the read FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQS</ipxact:name>
            <ipxact:description>This register is used to read and clear interrupt requests, regardless of IRQEN register and whether the interrupt is enabled or disabled.</ipxact:description>
            <ipxact:addressOffset>'h30</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in write mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in read mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Error on mailbox access
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQEN</ipxact:name>
            <ipxact:description>This register is used to enable and disable which interrupts are sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h38</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: Write threshold IRQ disabled
[1]: Write threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: Read threshold IRQ disabled
[1]: Read threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: Error IRQ disabled
[1]: Error IRQ enabled</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQP</ipxact:name>
            <ipxact:description>This register is used to read the current status of the interrupts sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h40</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: No write threshold IRQ pending
[1]: Write threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: No read threshold IRQ pending
[1]: Read threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: No error IRQ pending
[1]: Error IRQ pending</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>CTRL</ipxact:name>
            <ipxact:addressOffset>'h48</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wflush</ipxact:name>
              <ipxact:description>Flush the write FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rflush</ipxact:name>
              <ipxact:description>Flush the read FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted; a word the peer pushes in that cycle
is discarded.</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
        <ipxact:registerFile>
          <ipxact:name>inbound_mailbox_6</ipxact:name>
          <ipxact:displayName>AXI-Lite Mailbox Address Map</ipxact:displayName>
          <ipxact:description>Register interface for a single AXI-Lite mailbox: data FIFOs, level and status flags, and interrupt controls.</ipxact:description>
          <ipxact:addressOffset>'h6800</ipxact:addressOffset>
          <ipxact:range>'h50</ipxact:range>
          <ipxact:register>
            <ipxact:name>WRITE_DATA</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>write_data</ipxact:name>
              <ipxact:description>Write data to mailbox fifo. Any write pushes one entry, irrespective of WSTRB,
including a write with no byte lanes enabled; byte lanes whose strobe is 0 are
pushed as 0.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>READ_DATA</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register pops one whole 64-bit entry
from the mailbox fifo, and only the byte lanes it requests are returned. A 32-bit
read of either half therefore discards the other half of the entry; read this
register with 64-bit accesses. A read while the fifo is empty returns
0x0000_0000_FEED_DEAD with an error response.</ipxact:description>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_data</ipxact:name>
              <ipxact:description>Read data from mailbox fifo</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>modify</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>empty</ipxact:name>
              <ipxact:description>0: Data is available to read, 1: Data is not available to read</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h1</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>full</ipxact:name>
              <ipxact:description>0: Space is available to write, 1: Space is not available to write</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_level_above_thresh</ipxact:name>
              <ipxact:description>If set, write fifo level is higher than threshold set in WIRQT</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>read_level_above_thresh</ipxact:name>
              <ipxact:description>If set, read fifo level is higher than threshold set in RIRQT</ipxact:description>
              <ipxact:bitOffset>3</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>ERROR_FLAGS</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register clears every flag in it. The
flags are only returned in the lower 32 bits, so a 32-bit read of the upper half
returns 0 and still clears them; read this register with 64-bit accesses or at its
lower half.</ipxact:description>
            <ipxact:addressOffset>'h18</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_error</ipxact:name>
              <ipxact:description>Attempted read from an empty mailbox</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_error</ipxact:name>
              <ipxact:description>Attempted write to a full mailbox</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>WIRQT</ipxact:name>
            <ipxact:addressOffset>'h20</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wirqt</ipxact:name>
              <ipxact:description>When the usage pointer of the FIFO connected to the W channel exceeds this value, a write threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the write FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>RIRQT</ipxact:name>
            <ipxact:addressOffset>'h28</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>rirqt</ipxact:name>
              <ipxact:description>When the fill pointer of the FIFO connected to the R channel exceeds this value, a read threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the read FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQS</ipxact:name>
            <ipxact:description>This register is used to read and clear interrupt requests, regardless of IRQEN register and whether the interrupt is enabled or disabled.</ipxact:description>
            <ipxact:addressOffset>'h30</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in write mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in read mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Error on mailbox access
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQEN</ipxact:name>
            <ipxact:description>This register is used to enable and disable which interrupts are sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h38</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: Write threshold IRQ disabled
[1]: Write threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: Read threshold IRQ disabled
[1]: Read threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: Error IRQ disabled
[1]: Error IRQ enabled</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQP</ipxact:name>
            <ipxact:description>This register is used to read the current status of the interrupts sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h40</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: No write threshold IRQ pending
[1]: Write threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: No read threshold IRQ pending
[1]: Read threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: No error IRQ pending
[1]: Error IRQ pending</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>CTRL</ipxact:name>
            <ipxact:addressOffset>'h48</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wflush</ipxact:name>
              <ipxact:description>Flush the write FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rflush</ipxact:name>
              <ipxact:description>Flush the read FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted; a word the peer pushes in that cycle
is discarded.</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
        <ipxact:registerFile>
          <ipxact:name>outbound_mailbox_7</ipxact:name>
          <ipxact:displayName>AXI-Lite Mailbox Address Map</ipxact:displayName>
          <ipxact:description>Register interface for a single AXI-Lite mailbox: data FIFOs, level and status flags, and interrupt controls.</ipxact:description>
          <ipxact:addressOffset>'h7000</ipxact:addressOffset>
          <ipxact:range>'h50</ipxact:range>
          <ipxact:register>
            <ipxact:name>WRITE_DATA</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>write_data</ipxact:name>
              <ipxact:description>Write data to mailbox fifo. Any write pushes one entry, irrespective of WSTRB,
including a write with no byte lanes enabled; byte lanes whose strobe is 0 are
pushed as 0.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>READ_DATA</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register pops one whole 64-bit entry
from the mailbox fifo, and only the byte lanes it requests are returned. A 32-bit
read of either half therefore discards the other half of the entry; read this
register with 64-bit accesses. A read while the fifo is empty returns
0x0000_0000_FEED_DEAD with an error response.</ipxact:description>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_data</ipxact:name>
              <ipxact:description>Read data from mailbox fifo</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>modify</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>empty</ipxact:name>
              <ipxact:description>0: Data is available to read, 1: Data is not available to read</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h1</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>full</ipxact:name>
              <ipxact:description>0: Space is available to write, 1: Space is not available to write</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_level_above_thresh</ipxact:name>
              <ipxact:description>If set, write fifo level is higher than threshold set in WIRQT</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>read_level_above_thresh</ipxact:name>
              <ipxact:description>If set, read fifo level is higher than threshold set in RIRQT</ipxact:description>
              <ipxact:bitOffset>3</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>ERROR_FLAGS</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register clears every flag in it. The
flags are only returned in the lower 32 bits, so a 32-bit read of the upper half
returns 0 and still clears them; read this register with 64-bit accesses or at its
lower half.</ipxact:description>
            <ipxact:addressOffset>'h18</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_error</ipxact:name>
              <ipxact:description>Attempted read from an empty mailbox</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_error</ipxact:name>
              <ipxact:description>Attempted write to a full mailbox</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>WIRQT</ipxact:name>
            <ipxact:addressOffset>'h20</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wirqt</ipxact:name>
              <ipxact:description>When the usage pointer of the FIFO connected to the W channel exceeds this value, a write threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the write FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>RIRQT</ipxact:name>
            <ipxact:addressOffset>'h28</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>rirqt</ipxact:name>
              <ipxact:description>When the fill pointer of the FIFO connected to the R channel exceeds this value, a read threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the read FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQS</ipxact:name>
            <ipxact:description>This register is used to read and clear interrupt requests, regardless of IRQEN register and whether the interrupt is enabled or disabled.</ipxact:description>
            <ipxact:addressOffset>'h30</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in write mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in read mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Error on mailbox access
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQEN</ipxact:name>
            <ipxact:description>This register is used to enable and disable which interrupts are sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h38</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: Write threshold IRQ disabled
[1]: Write threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: Read threshold IRQ disabled
[1]: Read threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: Error IRQ disabled
[1]: Error IRQ enabled</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQP</ipxact:name>
            <ipxact:description>This register is used to read the current status of the interrupts sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h40</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: No write threshold IRQ pending
[1]: Write threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: No read threshold IRQ pending
[1]: Read threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: No error IRQ pending
[1]: Error IRQ pending</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>CTRL</ipxact:name>
            <ipxact:addressOffset>'h48</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wflush</ipxact:name>
              <ipxact:description>Flush the write FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rflush</ipxact:name>
              <ipxact:description>Flush the read FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted; a word the peer pushes in that cycle
is discarded.</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
        <ipxact:registerFile>
          <ipxact:name>inbound_mailbox_7</ipxact:name>
          <ipxact:displayName>AXI-Lite Mailbox Address Map</ipxact:displayName>
          <ipxact:description>Register interface for a single AXI-Lite mailbox: data FIFOs, level and status flags, and interrupt controls.</ipxact:description>
          <ipxact:addressOffset>'h7800</ipxact:addressOffset>
          <ipxact:range>'h50</ipxact:range>
          <ipxact:register>
            <ipxact:name>WRITE_DATA</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>write_data</ipxact:name>
              <ipxact:description>Write data to mailbox fifo. Any write pushes one entry, irrespective of WSTRB,
including a write with no byte lanes enabled; byte lanes whose strobe is 0 are
pushed as 0.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>READ_DATA</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register pops one whole 64-bit entry
from the mailbox fifo, and only the byte lanes it requests are returned. A 32-bit
read of either half therefore discards the other half of the entry; read this
register with 64-bit accesses. A read while the fifo is empty returns
0x0000_0000_FEED_DEAD with an error response.</ipxact:description>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_data</ipxact:name>
              <ipxact:description>Read data from mailbox fifo</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>modify</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>STATUS</ipxact:name>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>empty</ipxact:name>
              <ipxact:description>0: Data is available to read, 1: Data is not available to read</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h1</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>full</ipxact:name>
              <ipxact:description>0: Space is available to write, 1: Space is not available to write</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_level_above_thresh</ipxact:name>
              <ipxact:description>If set, write fifo level is higher than threshold set in WIRQT</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>read_level_above_thresh</ipxact:name>
              <ipxact:description>If set, read fifo level is higher than threshold set in RIRQT</ipxact:description>
              <ipxact:bitOffset>3</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>ERROR_FLAGS</ipxact:name>
            <ipxact:description>A read of any size or alignment within this register clears every flag in it. The
flags are only returned in the lower 32 bits, so a 32-bit read of the upper half
returns 0 and still clears them; read this register with 64-bit accesses or at its
lower half.</ipxact:description>
            <ipxact:addressOffset>'h18</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_error</ipxact:name>
              <ipxact:description>Attempted read from an empty mailbox</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_error</ipxact:name>
              <ipxact:description>Attempted write to a full mailbox</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
              <ipxact:readAction>clear</ipxact:readAction>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>WIRQT</ipxact:name>
            <ipxact:addressOffset>'h20</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wirqt</ipxact:name>
              <ipxact:description>When the usage pointer of the FIFO connected to the W channel exceeds this value, a write threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the write FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>RIRQT</ipxact:name>
            <ipxact:addressOffset>'h28</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>rirqt</ipxact:name>
              <ipxact:description>When the fill pointer of the FIFO connected to the R channel exceeds this value, a read threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the read FIFO is full.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>64</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQS</ipxact:name>
            <ipxact:description>This register is used to read and clear interrupt requests, regardless of IRQEN register and whether the interrupt is enabled or disabled.</ipxact:description>
            <ipxact:addressOffset>'h30</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in write mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Usage level threshold in read mailbox exceeded
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>On read:
[0]: No interrupt request
[1]: Error on mailbox access
On write:
[0]: No acknowledge
[1]: Acknowledge and clear interrupt request</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQEN</ipxact:name>
            <ipxact:description>This register is used to enable and disable which interrupts are sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h38</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: Write threshold IRQ disabled
[1]: Write threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: Read threshold IRQ disabled
[1]: Read threshold IRQ enabled</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: Error IRQ disabled
[1]: Error IRQ enabled</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>IRQP</ipxact:name>
            <ipxact:description>This register is used to read the current status of the interrupts sent to the CPU.</ipxact:description>
            <ipxact:addressOffset>'h40</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wtirq</ipxact:name>
              <ipxact:description>[0]: No write threshold IRQ pending
[1]: Write threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rtirq</ipxact:name>
              <ipxact:description>[0]: No read threshold IRQ pending
[1]: Read threshold IRQ pending</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>eirq</ipxact:name>
              <ipxact:description>[0]: No error IRQ pending
[1]: Error IRQ pending</ipxact:description>
              <ipxact:bitOffset>2</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>CTRL</ipxact:name>
            <ipxact:addressOffset>'h48</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>wflush</ipxact:name>
              <ipxact:description>Flush the write FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>rflush</ipxact:name>
              <ipxact:description>Flush the read FIFO for this port. The FIFO empties at the end of the
cycle in which this write is accepted; a word the peer pushes in that cycle
is discarded.</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>write-only</ipxact:access>
              <ipxact:modifiedWriteValue>modify</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>local_master_alias_remap_ctrl_wrap</ipxact:name>
        <ipxact:displayName>AXI Alias Remap Wrapper Address Map</ipxact:displayName>
        <ipxact:description>Wrapper address map instantiating one alias remap register block per remap region.</ipxact:description>
        <ipxact:baseAddress>'h10a10000</ipxact:baseAddress>
        <ipxact:range>'h200</ipxact:range>
        <ipxact:width>64</ipxact:width>
        <ipxact:registerFile>
          <ipxact:name>alias_remap</ipxact:name>
          <ipxact:displayName>AXI Alias Remap Address Map</ipxact:displayName>
          <ipxact:description>TLB Registers for address remapping and attribute tagging</ipxact:description>
          <ipxact:dim>16</ipxact:dim>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:range>'h20</ipxact:range>
          <ipxact:registerFile>
            <ipxact:name>REGION</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:range>'h18</ipxact:range>
            <ipxact:register>
              <ipxact:name>region_start</ipxact:name>
              <ipxact:addressOffset>'h0</ipxact:addressOffset>
              <ipxact:size>64</ipxact:size>
              <ipxact:field>
                <ipxact:name>start_addr</ipxact:name>
                <ipxact:description>Start of remap region</ipxact:description>
                <ipxact:bitOffset>12</ipxact:bitOffset>
                <ipxact:resets>
                  <ipxact:reset>
                    <ipxact:value>'h0</ipxact:value>
                  </ipxact:reset>
                </ipxact:resets>
                <ipxact:bitWidth>44</ipxact:bitWidth>
                <ipxact:access>read-write</ipxact:access>
              </ipxact:field>
            </ipxact:register>
            <ipxact:register>
              <ipxact:name>region_end</ipxact:name>
              <ipxact:addressOffset>'h8</ipxact:addressOffset>
              <ipxact:size>64</ipxact:size>
              <ipxact:field>
                <ipxact:name>end_addr</ipxact:name>
                <ipxact:description>End of remap region (non-inclusive). A region whose end is at or below its start contains no address and never remaps.</ipxact:description>
                <ipxact:bitOffset>12</ipxact:bitOffset>
                <ipxact:resets>
                  <ipxact:reset>
                    <ipxact:value>'h0</ipxact:value>
                  </ipxact:reset>
                </ipxact:resets>
                <ipxact:bitWidth>44</ipxact:bitWidth>
                <ipxact:access>read-write</ipxact:access>
              </ipxact:field>
            </ipxact:register>
            <ipxact:register>
              <ipxact:name>region_attrs</ipxact:name>
              <ipxact:addressOffset>'h10</ipxact:addressOffset>
              <ipxact:size>64</ipxact:size>
              <ipxact:field>
                <ipxact:name>offset</ipxact:name>
                <ipxact:description>The value of this field is added to bits [55:12] of the input address when it falls within the remap region. The addition is modulo 2^44, so a carry out of bit 55 is discarded. The lower 12 bits of the address are preserved unchanged. When more than one valid region contains the address, the lowest-numbered region applies.</ipxact:description>
                <ipxact:bitOffset>12</ipxact:bitOffset>
                <ipxact:resets>
                  <ipxact:reset>
                    <ipxact:value>'h0</ipxact:value>
                  </ipxact:reset>
                </ipxact:resets>
                <ipxact:bitWidth>44</ipxact:bitWidth>
                <ipxact:access>read-write</ipxact:access>
              </ipxact:field>
              <ipxact:field>
                <ipxact:name>cacheable</ipxact:name>
                <ipxact:description>Set to change the value of the axcache field of the transaction. This field will override all existing axcache bits.</ipxact:description>
                <ipxact:bitOffset>56</ipxact:bitOffset>
                <ipxact:resets>
                  <ipxact:reset>
                    <ipxact:value>'h0</ipxact:value>
                  </ipxact:reset>
                </ipxact:resets>
                <ipxact:bitWidth>4</ipxact:bitWidth>
                <ipxact:access>read-write</ipxact:access>
              </ipxact:field>
              <ipxact:field>
                <ipxact:name>valid</ipxact:name>
                <ipxact:description>If set, this remap will be active</ipxact:description>
                <ipxact:bitOffset>63</ipxact:bitOffset>
                <ipxact:resets>
                  <ipxact:reset>
                    <ipxact:value>'h0</ipxact:value>
                  </ipxact:reset>
                </ipxact:resets>
                <ipxact:bitWidth>1</ipxact:bitWidth>
                <ipxact:access>read-write</ipxact:access>
              </ipxact:field>
            </ipxact:register>
          </ipxact:registerFile>
        </ipxact:registerFile>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>ap_output_remap_ctrl_wrap</ipxact:name>
        <ipxact:displayName>Output Remap Wrapper Address Map</ipxact:displayName>
        <ipxact:description>Wrapper address map instantiating one output remap register block per remap region.</ipxact:description>
        <ipxact:baseAddress>'h10a10200</ipxact:baseAddress>
        <ipxact:range>'h80</ipxact:range>
        <ipxact:width>64</ipxact:width>
        <ipxact:registerFile>
          <ipxact:name>output_remap</ipxact:name>
          <ipxact:displayName>Output Remap Address Map</ipxact:displayName>
          <ipxact:description>Address-translation registers that remap outbound transactions and tag their attributes.</ipxact:description>
          <ipxact:dim>16</ipxact:dim>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:range>'h8</ipxact:range>
          <ipxact:registerFile>
            <ipxact:name>REGION</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:range>'h8</ipxact:range>
            <ipxact:register>
              <ipxact:name>region_attrs</ipxact:name>
              <ipxact:addressOffset>'h0</ipxact:addressOffset>
              <ipxact:size>64</ipxact:size>
              <ipxact:field>
                <ipxact:name>offset</ipxact:name>
                <ipxact:description>Address translation for remap region. RTL will use the number of bits appropriate for region granulaity.
e.g. SMC: 8 * 1MB regions --&gt; 20 bits of address space per region, 36 MSBs from this register used
    SEP: 16 * 512KB regions --&gt; 19 bits of address space per region, 37 MSBs from this register used</ipxact:description>
                <ipxact:bitOffset>0</ipxact:bitOffset>
                <ipxact:resets>
                  <ipxact:reset>
                    <ipxact:value>'h0</ipxact:value>
                  </ipxact:reset>
                </ipxact:resets>
                <ipxact:bitWidth>56</ipxact:bitWidth>
                <ipxact:access>read-write</ipxact:access>
              </ipxact:field>
              <ipxact:field>
                <ipxact:name>valid</ipxact:name>
                <ipxact:description>If set, accesses to this region are remapped by offset; if clear, they pass through with their address unchanged</ipxact:description>
                <ipxact:bitOffset>63</ipxact:bitOffset>
                <ipxact:resets>
                  <ipxact:reset>
                    <ipxact:value>'h0</ipxact:value>
                  </ipxact:reset>
                </ipxact:resets>
                <ipxact:bitWidth>1</ipxact:bitWidth>
                <ipxact:access>read-write</ipxact:access>
              </ipxact:field>
            </ipxact:register>
          </ipxact:registerFile>
        </ipxact:registerFile>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>stee_output_remap_ctrl_wrap</ipxact:name>
        <ipxact:displayName>Output Remap Wrapper Address Map</ipxact:displayName>
        <ipxact:description>Wrapper address map instantiating one output remap register block per remap region.</ipxact:description>
        <ipxact:baseAddress>'h10a10300</ipxact:baseAddress>
        <ipxact:range>'h80</ipxact:range>
        <ipxact:width>64</ipxact:width>
        <ipxact:registerFile>
          <ipxact:name>output_remap</ipxact:name>
          <ipxact:displayName>Output Remap Address Map</ipxact:displayName>
          <ipxact:description>Address-translation registers that remap outbound transactions and tag their attributes.</ipxact:description>
          <ipxact:dim>16</ipxact:dim>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:range>'h8</ipxact:range>
          <ipxact:registerFile>
            <ipxact:name>REGION</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:range>'h8</ipxact:range>
            <ipxact:register>
              <ipxact:name>region_attrs</ipxact:name>
              <ipxact:addressOffset>'h0</ipxact:addressOffset>
              <ipxact:size>64</ipxact:size>
              <ipxact:field>
                <ipxact:name>offset</ipxact:name>
                <ipxact:description>Address translation for remap region. RTL will use the number of bits appropriate for region granulaity.
e.g. SMC: 8 * 1MB regions --&gt; 20 bits of address space per region, 36 MSBs from this register used
    SEP: 16 * 512KB regions --&gt; 19 bits of address space per region, 37 MSBs from this register used</ipxact:description>
                <ipxact:bitOffset>0</ipxact:bitOffset>
                <ipxact:resets>
                  <ipxact:reset>
                    <ipxact:value>'h0</ipxact:value>
                  </ipxact:reset>
                </ipxact:resets>
                <ipxact:bitWidth>56</ipxact:bitWidth>
                <ipxact:access>read-write</ipxact:access>
              </ipxact:field>
              <ipxact:field>
                <ipxact:name>valid</ipxact:name>
                <ipxact:description>If set, accesses to this region are remapped by offset; if clear, they pass through with their address unchanged</ipxact:description>
                <ipxact:bitOffset>63</ipxact:bitOffset>
                <ipxact:resets>
                  <ipxact:reset>
                    <ipxact:value>'h0</ipxact:value>
                  </ipxact:reset>
                </ipxact:resets>
                <ipxact:bitWidth>1</ipxact:bitWidth>
                <ipxact:access>read-write</ipxact:access>
              </ipxact:field>
            </ipxact:register>
          </ipxact:registerFile>
        </ipxact:registerFile>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>outbound_filter_ctrl_wrap</ipxact:name>
        <ipxact:displayName>AXI Filter Wrapper Address Map</ipxact:displayName>
        <ipxact:description>Wrapper address map instantiating one filter control register block per filter entry.</ipxact:description>
        <ipxact:baseAddress>'h10a20000</ipxact:baseAddress>
        <ipxact:range>'h400</ipxact:range>
        <ipxact:width>64</ipxact:width>
        <ipxact:registerFile>
          <ipxact:name>filter_ctrl</ipxact:name>
          <ipxact:displayName>AXI Filter Control Address Map</ipxact:displayName>
          <ipxact:description>Per-filter access-control registers defining permitted address ranges and transaction attributes.</ipxact:description>
          <ipxact:dim>32</ipxact:dim>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:range>'h20</ipxact:range>
          <ipxact:register>
            <ipxact:name>FILTER_CONFIG</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_allowed</ipxact:name>
              <ipxact:description>Upon match of transaction to filter fields, whether the transaction has read permissions</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_allowed</ipxact:name>
              <ipxact:description>Upon match of transaction to filter fields, whether the transaction has write permissions</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>entry_enabled</ipxact:name>
              <ipxact:description>Filter entry enabled. A = 0 means this entry is disabled, A = 1 means this entry is enabled and will be used to filter</ipxact:description>
              <ipxact:bitOffset>4</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>allow_ns</ipxact:name>
              <ipxact:description>Secure and Non-secure is categorized as AxPROT[1] in the AXI protocol, where AxPROT[1] == 0 means secure and AxPROT[1] == 1 means Non-secure.
Filter entry will match if AxPROT[1] matches the value in this field</ipxact:description>
              <ipxact:bitOffset>8</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>data_bus_width</ipxact:name>
              <ipxact:description>Data bus width in bytes, encoded as 2^value: log2 of the instance's AXI data width in bytes, 3 for a 64-bit bus. The register has no storage, and the reset value is the 64-bit case.</ipxact:description>
              <ipxact:bitOffset>12</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h3</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>3</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>src_id</ipxact:name>
              <ipxact:description>Source ID field to match. Filter entry will match if the transactions src_id matches the value in this field.
A value of 0 in this field is a wildcard: src_id matching is bypassed and the entry matches any src_id.
Consequently there is no way to match only transactions whose src_id is 0.</ipxact:description>
              <ipxact:bitOffset>16</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>4</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>group_id</ipxact:name>
              <ipxact:description>Group ID field to match. Filter entry will match if the transactions group_id matches the value in this field.
Note the corner case is the opposite of src_id: the bypass keys off the transaction, not this field.
A transaction whose group_id is 0 matches regardless of this field, and a value of 0 here is not a wildcard.
Unused for SEP/SMC, where group_id filtering is disabled at build time and this field has no effect</ipxact:description>
              <ipxact:bitOffset>20</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>4</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>allow_burst</ipxact:name>
              <ipxact:description>Filter entry will match if this field is 1 or if this field is 0 and the burst len AxLEN is 0.
This field also selects the granule of the address range: 4KB when it is 1,
2^data_bus_width bytes when it is 0. See start_addr and end_addr for how the range is widened
to that granule.</ipxact:description>
              <ipxact:bitOffset>24</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>locked</ipxact:name>
              <ipxact:description>Lock filter configurations. Write once register.
Once set, this bit cannot be cleared, and every subsequent write to this
filter entry's FILTER_CONFIG, START_ADDR and END_ADDR registers terminates
with an error response and leaves the register unchanged; reads still
return the locked configuration.</ipxact:description>
              <ipxact:bitOffset>63</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>START_ADDR</ipxact:name>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>start_addr</ipxact:name>
              <ipxact:description>Start of the allowable address range, rounded down to the base of its granule.
The granule is 4KB when allow_burst is 1, and 2^data_bus_width bytes when allow_burst is 0.
Address matching ignores the address bits below the granule, so the accepted range always
spans whole granules and is never narrower than one: a range shorter than the granule,
start_addr == end_addr included, still admits the whole granule, and two granules if it
straddles a granule boundary.
Hardware writes the rounded start_addr and end_addr back into these fields only when both
land in the same granule; otherwise readback returns the programmed values even though
matching is still granule-aligned.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>56</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>END_ADDR</ipxact:name>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>end_addr</ipxact:name>
              <ipxact:description>End of the allowable address range, rounded up to the top of its granule.
The granule and the write-back behaviour are described under start_addr.
Resets to 7, the top of the first 8-byte granule that applies while bursts are
disabled on a 64-bit bus; the reset does not follow the data width.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h7</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>56</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>inbound_filter_ctrl_wrap</ipxact:name>
        <ipxact:displayName>AXI Filter Wrapper Address Map</ipxact:displayName>
        <ipxact:description>Wrapper address map instantiating one filter control register block per filter entry.</ipxact:description>
        <ipxact:baseAddress>'h10a21000</ipxact:baseAddress>
        <ipxact:range>'h200</ipxact:range>
        <ipxact:width>64</ipxact:width>
        <ipxact:registerFile>
          <ipxact:name>filter_ctrl</ipxact:name>
          <ipxact:displayName>AXI Filter Control Address Map</ipxact:displayName>
          <ipxact:description>Per-filter access-control registers defining permitted address ranges and transaction attributes.</ipxact:description>
          <ipxact:dim>16</ipxact:dim>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:range>'h20</ipxact:range>
          <ipxact:register>
            <ipxact:name>FILTER_CONFIG</ipxact:name>
            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>read_allowed</ipxact:name>
              <ipxact:description>Upon match of transaction to filter fields, whether the transaction has read permissions</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>write_allowed</ipxact:name>
              <ipxact:description>Upon match of transaction to filter fields, whether the transaction has write permissions</ipxact:description>
              <ipxact:bitOffset>1</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>entry_enabled</ipxact:name>
              <ipxact:description>Filter entry enabled. A = 0 means this entry is disabled, A = 1 means this entry is enabled and will be used to filter</ipxact:description>
              <ipxact:bitOffset>4</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>allow_ns</ipxact:name>
              <ipxact:description>Secure and Non-secure is categorized as AxPROT[1] in the AXI protocol, where AxPROT[1] == 0 means secure and AxPROT[1] == 1 means Non-secure.
Filter entry will match if AxPROT[1] matches the value in this field</ipxact:description>
              <ipxact:bitOffset>8</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>data_bus_width</ipxact:name>
              <ipxact:description>Data bus width in bytes, encoded as 2^value: log2 of the instance's AXI data width in bytes, 3 for a 64-bit bus. The register has no storage, and the reset value is the 64-bit case.</ipxact:description>
              <ipxact:bitOffset>12</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h3</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>3</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-only</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>src_id</ipxact:name>
              <ipxact:description>Source ID field to match. Filter entry will match if the transactions src_id matches the value in this field.
A value of 0 in this field is a wildcard: src_id matching is bypassed and the entry matches any src_id.
Consequently there is no way to match only transactions whose src_id is 0.</ipxact:description>
              <ipxact:bitOffset>16</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>4</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>group_id</ipxact:name>
              <ipxact:description>Group ID field to match. Filter entry will match if the transactions group_id matches the value in this field.
Note the corner case is the opposite of src_id: the bypass keys off the transaction, not this field.
A transaction whose group_id is 0 matches regardless of this field, and a value of 0 here is not a wildcard.
Unused for SEP/SMC, where group_id filtering is disabled at build time and this field has no effect</ipxact:description>
              <ipxact:bitOffset>20</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>4</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>allow_burst</ipxact:name>
              <ipxact:description>Filter entry will match if this field is 1 or if this field is 0 and the burst len AxLEN is 0.
This field also selects the granule of the address range: 4KB when it is 1,
2^data_bus_width bytes when it is 0. See start_addr and end_addr for how the range is widened
to that granule.</ipxact:description>
              <ipxact:bitOffset>24</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
            <ipxact:field>
              <ipxact:name>locked</ipxact:name>
              <ipxact:description>Lock filter configurations. Write once register.
Once set, this bit cannot be cleared, and every subsequent write to this
filter entry's FILTER_CONFIG, START_ADDR and END_ADDR registers terminates
with an error response and leaves the register unchanged; reads still
return the locked configuration.</ipxact:description>
              <ipxact:bitOffset>63</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>1</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
              <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>START_ADDR</ipxact:name>
            <ipxact:addressOffset>'h8</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>start_addr</ipxact:name>
              <ipxact:description>Start of the allowable address range, rounded down to the base of its granule.
The granule is 4KB when allow_burst is 1, and 2^data_bus_width bytes when allow_burst is 0.
Address matching ignores the address bits below the granule, so the accepted range always
spans whole granules and is never narrower than one: a range shorter than the granule,
start_addr == end_addr included, still admits the whole granule, and two granules if it
straddles a granule boundary.
Hardware writes the rounded start_addr and end_addr back into these fields only when both
land in the same granule; otherwise readback returns the programmed values even though
matching is still granule-aligned.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h0</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>56</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
          <ipxact:register>
            <ipxact:name>END_ADDR</ipxact:name>
            <ipxact:addressOffset>'h10</ipxact:addressOffset>
            <ipxact:size>64</ipxact:size>
            <ipxact:field>
              <ipxact:name>end_addr</ipxact:name>
              <ipxact:description>End of the allowable address range, rounded up to the top of its granule.
The granule and the write-back behaviour are described under start_addr.
Resets to 7, the top of the first 8-byte granule that applies while bursts are
disabled on a 64-bit bus; the reset does not follow the data width.</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h7</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>56</ipxact:bitWidth>
              <ipxact:volatile>true</ipxact:volatile>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>sep_cpu_ctrl</ipxact:name>
        <ipxact:displayName>SEP CPU Control Address Map</ipxact:displayName>
        <ipxact:description>SEP CPU control and status registers: PKA and crypto configuration, boot and fast-memory enables, fuse-sense status, and interrupt controls.</ipxact:description>
        <ipxact:baseAddress>'h10a30000</ipxact:baseAddress>
        <ipxact:range>'h1008</ipxact:range>
        <ipxact:width>64</ipxact:width>
        <ipxact:register>
          <ipxact:name>CLOCK_GATE_CTRL</ipxact:name>
          <ipxact:description>TODO: clock-gate control - placeholder fields, not yet implemented.</ipxact:description>
          <ipxact:addressOffset>'h8</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>pka_cg_enable</ipxact:name>
            <ipxact:description>Reserved - PKA clock-gate enable, not yet implemented.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>REFERENCE_COUNTER</ipxact:name>
          <ipxact:addressOffset>'h10</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>rc</ipxact:name>
            <ipxact:description>SEP REFERENCE COUNTER, counting after deassert of the boot-qualified SEP
reset. Write once, then poll this register until the readback reflects the
written value before writing again. The counter keeps advancing, so the
readback is at or just above the written value rather than equal to it.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>64</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>TIMEOUT_INTERRUPT</ipxact:name>
          <ipxact:description>Reserved - per-block timeout interrupt not yet implemented.</ipxact:description>
          <ipxact:addressOffset>'h18</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>reserved</ipxact:name>
            <ipxact:description>Reserved - timeout interrupt status not yet implemented.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>PKA_CTRL</ipxact:name>
          <ipxact:description>TODO: PKA control - placeholder fields, not yet implemented.</ipxact:description>
          <ipxact:addressOffset>'h20</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>pka_dpa_disable</ipxact:name>
            <ipxact:description>Reserved - disable DPA countermeasures in PKA, not yet implemented.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>pka_noise_src</ipxact:name>
            <ipxact:description>Reserved - PKA noise source select, not yet implemented.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>pka_noise_src_valid</ipxact:name>
            <ipxact:description>Reserved - PKA noise source valid, not yet implemented.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>TIMEOUT_COUNT_DMA</ipxact:name>
          <ipxact:description>Reserved - per-block timeout count/threshold not yet implemented.</ipxact:description>
          <ipxact:addressOffset>'h28</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>reserved</ipxact:name>
            <ipxact:description>Reserved - timeout count not yet implemented.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>TIMEOUT_COUNT_SYS_IN</ipxact:name>
          <ipxact:description>Reserved - per-block timeout count/threshold not yet implemented.</ipxact:description>
          <ipxact:addressOffset>'h30</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>reserved</ipxact:name>
            <ipxact:description>Reserved - timeout count not yet implemented.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>TIMEOUT_COUNT_MAILBOX_INBOUND</ipxact:name>
          <ipxact:description>Reserved - per-block timeout count/threshold not yet implemented.</ipxact:description>
          <ipxact:addressOffset>'h38</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>reserved</ipxact:name>
            <ipxact:description>Reserved - timeout count not yet implemented.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>TIMEOUT_COUNT_MAILBOX_OUTBOUND</ipxact:name>
          <ipxact:description>Reserved - per-block timeout count/threshold not yet implemented.</ipxact:description>
          <ipxact:addressOffset>'h40</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>reserved</ipxact:name>
            <ipxact:description>Reserved - timeout count not yet implemented.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>TIMEOUT_COUNT_ENTROPY_WRITE</ipxact:name>
          <ipxact:description>Reserved - per-block timeout count/threshold not yet implemented.</ipxact:description>
          <ipxact:addressOffset>'h48</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>reserved</ipxact:name>
            <ipxact:description>Reserved - timeout count not yet implemented.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>TIMEOUT_COUNT_ENTROPY_READ</ipxact:name>
          <ipxact:description>Reserved - per-block timeout count/threshold not yet implemented.</ipxact:description>
          <ipxact:addressOffset>'h50</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>reserved</ipxact:name>
            <ipxact:description>Reserved - timeout count not yet implemented.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>TIMEOUT_COUNT_FILTER_OUT</ipxact:name>
          <ipxact:description>Reserved - per-block timeout count/threshold not yet implemented.</ipxact:description>
          <ipxact:addressOffset>'h58</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>reserved</ipxact:name>
            <ipxact:description>Reserved - timeout count not yet implemented.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>TIMEOUT_COUNT_ALIAS_REMAP</ipxact:name>
          <ipxact:description>Reserved - per-block timeout count/threshold not yet implemented.</ipxact:description>
          <ipxact:addressOffset>'h60</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>reserved</ipxact:name>
            <ipxact:description>Reserved - timeout count not yet implemented.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>TIMEOUT_ENABLE</ipxact:name>
          <ipxact:description>Reserved - per-block timeout enable not yet implemented.</ipxact:description>
          <ipxact:addressOffset>'h68</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>reserved</ipxact:name>
            <ipxact:description>Reserved - timeout monitors not yet implemented.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>TIMEOUT_CLEAR</ipxact:name>
          <ipxact:description>Reserved - per-block timeout interrupt-clear not yet implemented.</ipxact:description>
          <ipxact:addressOffset>'h70</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>reserved</ipxact:name>
            <ipxact:description>Reserved - timeout monitors not yet implemented.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>TIMEOUT_MODE</ipxact:name>
          <ipxact:description>Reserved - per-block timeout mode not yet implemented.</ipxact:description>
          <ipxact:addressOffset>'h78</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>reserved</ipxact:name>
            <ipxact:description>Reserved - timeout monitors not yet implemented.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEP_TEST_CTRL</ipxact:name>
          <ipxact:addressOffset>'hb0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>sep_standalone</ipxact:name>
            <ipxact:description>SEP is standalone (not part of eg SMU)</ipxact:description>
            <ipxact:bitOffset>26</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fast_pka_en</ipxact:name>
            <ipxact:description>Fast PKA Enable</ipxact:description>
            <ipxact:bitOffset>27</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fast_sram_en</ipxact:name>
            <ipxact:description>Fast SRAM Enable</ipxact:description>
            <ipxact:bitOffset>28</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fast_dccm_en</ipxact:name>
            <ipxact:description>Fast DCCM Enable</ipxact:description>
            <ipxact:bitOffset>29</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fast_iccm_en</ipxact:name>
            <ipxact:description>Fast ICCM Enable</ipxact:description>
            <ipxact:bitOffset>30</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>fast_spi_en</ipxact:name>
            <ipxact:description>Fast SPI Enable</ipxact:description>
            <ipxact:bitOffset>31</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEP_GLOBAL_BASE_ADDR</ipxact:name>
          <ipxact:addressOffset>'hc0</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>addr</ipxact:name>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>56</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEP_LOCAL_BASE_ADDR</ipxact:name>
          <ipxact:addressOffset>'hc8</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>addr</ipxact:name>
            <ipxact:description>Base of the local alias window, which CPU and secure DMA accesses reach as
0x1000_0000 onwards. Only bits [31:0] are used;
bits [55:32] are ignored. Legal values are 0xD000_0000 to 0xFFFF_FFFF; other
values overlap fixed SEP regions and are not supported. Keeping the reset value
is recommended. The window ends at 0xFFFF_FFFF and does not wrap, so a higher
base shortens it. An address outside the window is not translated.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'hd0000000</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>56</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEP_REGION_SIZE</ipxact:name>
          <ipxact:addressOffset>'hd0</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>size</ipxact:name>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1000000</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SMU_GLOBAL_BASE_ADDR</ipxact:name>
          <ipxact:addressOffset>'h100</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>addr</ipxact:name>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h80000000</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>56</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SMU_REGION_SIZE</ipxact:name>
          <ipxact:addressOffset>'h110</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>size</ipxact:name>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h40000000</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SMC_FUSE_SENSE_STATUS</ipxact:name>
          <ipxact:addressOffset>'h140</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>smc_fuse_sense_done</ipxact:name>
            <ipxact:description>This bit indicates when SMC's fuse sense is completed. While fuse sense if ongoing, SMC fabric will be in reset. Any requests to the SMC will hang.
When this is 1, it is safe to send requests to the SMC.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEP_FUSE_SENSE_STATUS</ipxact:name>
          <ipxact:addressOffset>'h150</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>sep_fuse_sense_done</ipxact:name>
            <ipxact:description>This reg is used to indicate the fuse sense status of SEP.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEP_SW_DEBUG</ipxact:name>
          <ipxact:addressOffset>'h178</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>sep_sw_debug</ipxact:name>
            <ipxact:description>software writtable debug information. This reg is routed to CLA</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEP_NMI_VEC</ipxact:name>
          <ipxact:description>NMI vector address for VeeR-EL2 CPU. The default value is 0xC000_0100. The NMI
interrupt is used for the WDT Bark interrupt.

WARNING: the reset value is a placeholder, not a usable handler. Firmware must
program this register with the address of its own NMI handler, and then set
SEP_NMI_VEC_LOCK, before enabling any NMI source (the WDT bark in particular).
If a bark arrives while the reset value is still in place, the CPU jumps to
0xC000_0100 in ICCM and executes whatever is there: arbitrary instructions if
the loaded image covers that location, or, if the fetch takes an
uncorrectable ICCM ECC error, an instruction access fault (mcause 0x1)
through mtvec.</ipxact:description>
          <ipxact:addressOffset>'h180</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>rsvd</ipxact:name>
            <ipxact:description>Reserved, bit 0 is always 0 (aligned)</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>nmi_vec</ipxact:name>
            <ipxact:description>NMI vector address [31:1] for VeeR-EL2 CPU. Bit 0 is always 0 (aligned).
Address where CPU jumps on Non-Maskable Interrupt. This is used for the
WDT Bark interrupt. The reset value does not point at a valid handler --
see the register description for the required programming order.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h60000080</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>31</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEP_NMI_VEC_LOCK</ipxact:name>
          <ipxact:description>Lock the NMI vector address. Once locked, the NMI vector address cannot be changed. The
NMI interrupt is used for the WDT Bark interrupt.</ipxact:description>
          <ipxact:addressOffset>'h188</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>lock</ipxact:name>
            <ipxact:description>Lock the NMI vector address. Once locked, the NMI vector address cannot be changed.
The NMI interrupt is used for the WDT Bark interrupt.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>EXT_TRNG_SRC_SEL</ipxact:name>
          <ipxact:description>Per-stream external TRNG source selection for crypto subsystem entropy muxes.</ipxact:description>
          <ipxact:addressOffset>'h190</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>sel</ipxact:name>
            <ipxact:description>TRNG source select per stream. Bit N selects the source for stream N
(bit0 = Key Manager, bit1 = crypto blocks, bit2 = entropy pool).
0 = internal DRBG output, 1 = external TRNG (default).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h7</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>3</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>EXT_TRNG_SRC_SEL_LOCK</ipxact:name>
          <ipxact:description>Lock the TRNG source selection. Once locked, EXT_TRNG_SRC_SEL cannot be changed until reset.</ipxact:description>
          <ipxact:addressOffset>'h198</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>lock</ipxact:name>
            <ipxact:description>Lock TRNG source selection. Once set, cannot be cleared by software.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToSet</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>KM_WIPE_CTRL</ipxact:name>
          <ipxact:description>Key Manager emergency wipe control.</ipxact:description>
          <ipxact:addressOffset>'h1a0</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>wipe_state</ipxact:name>
            <ipxact:description>Key Manager wipe state. A rising edge zeroes all KPV entries and sets the WIPE_STATE interrupt status.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>DMA_BUS_ERR_STATUS</ipxact:name>
          <ipxact:description>Secure DMA bridge fault status. Each bit is latched in hardware and held
until the corresponding DMA_BUS_ERR_CLEAR write. These bits also drive
dedicated PIC sources.

Neither bit is cleared by a CPU-only reset (the WDT resets the CPU without
resetting the DMA), so a bit read as set immediately after boot may describe
a fault from before that reset rather than a new one.</ipxact:description>
          <ipxact:addressOffset>'h1a8</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>reg_path_err</ipxact:name>
            <ipxact:description>Register-path bus error: a CPU access to a Secure DMA register returned
a TL-UL error response (an unmapped offset, or a partial write: a byte
strobe that misses a byte the register owns). The faulting access also
received SLVERR synchronously. A narrow read inside a register returns
OKAY.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>host_path_err</ipxact:name>
            <ipxact:description>DMA-master-path fault: either the fabric returned a non-OKAY AXI response
to a DMA transfer, or a TL-UL command-integrity check failed on a command
issued by the DMA. The latter is a fault-detection event with no other
reporting path.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>DMA_BUS_ERR_CLEAR</ipxact:name>
          <ipxact:description>Clear the DMA_BUS_ERR_STATUS bits. Writing 1 emits a single-cycle clear pulse
to both latches. A fault arriving in the same cycle as the clear still
latches, so acknowledging cannot drop a concurrent fault.</ipxact:description>
          <ipxact:addressOffset>'h1b0</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>clr</ipxact:name>
            <ipxact:description>Write 1 to clear both DMA_BUS_ERR_STATUS bits. Always reads 0.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>PERIPH_BUS_ERR_STATUS</ipxact:name>
          <ipxact:description>Peripheral register-bridge fault status, one bit per block. Each bit latches
when a CPU access to that block's registers returned a TL-UL error response
(an unmapped offset, or a partial write: a byte strobe that misses a byte the
register owns), and is held until the matching PERIPH_BUS_ERR_CLEAR bit is
written. The faulting access also received SLVERR synchronously. A narrow
read inside a register returns OKAY. The spi bit also latches the SPI host
fatal alert.

All bits OR together into a single PIC source, so read this register to
identify which block faulted.

No bit is cleared by a CPU-only reset (the WDT resets the CPU without
resetting the peripherals), so a bit read as set immediately after boot may
describe a fault from before that reset rather than a new one.</ipxact:description>
          <ipxact:addressOffset>'h1b8</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>aes</ipxact:name>
            <ipxact:description>AES register bridge error.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>hmac</ipxact:name>
            <ipxact:description>HMAC register bridge error.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>kmac</ipxact:name>
            <ipxact:description>KMAC register bridge error.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>otbn</ipxact:name>
            <ipxact:description>OTBN register bridge error.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>csrng</ipxact:name>
            <ipxact:description>CSRNG register bridge error (DRBG CSRNG path).</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>edn</ipxact:name>
            <ipxact:description>EDN register bridge error (DRBG EDN path).</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>wdt</ipxact:name>
            <ipxact:description>Watchdog timer register bridge error.</ipxact:description>
            <ipxact:bitOffset>6</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>spi</ipxact:name>
            <ipxact:description>SPI host register bridge error, or the SPI host fatal_fault alert (a
register-bus integrity fault, or a write of ALERT_TEST.fatal_fault). A
real integrity fault repeats the alert until the SEP reset, so clearing
this bit does not keep it clear.</ipxact:description>
            <ipxact:bitOffset>7</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>PERIPH_BUS_ERR_CLEAR</ipxact:name>
          <ipxact:description>Clear PERIPH_BUS_ERR_STATUS bits. Writing 1 to a bit emits a single-cycle
clear pulse to that block's latch; bit order matches
PERIPH_BUS_ERR_STATUS. Clears are per-block so acknowledging one block
cannot discard a fault another block raised between the status read and
this write. A fault arriving in the same cycle as its own clear still
latches.</ipxact:description>
          <ipxact:addressOffset>'h1c0</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>aes</ipxact:name>
            <ipxact:description>Write 1 to clear PERIPH_BUS_ERR_STATUS.aes. Always reads 0.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>hmac</ipxact:name>
            <ipxact:description>Write 1 to clear PERIPH_BUS_ERR_STATUS.hmac. Always reads 0.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>kmac</ipxact:name>
            <ipxact:description>Write 1 to clear PERIPH_BUS_ERR_STATUS.kmac. Always reads 0.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>otbn</ipxact:name>
            <ipxact:description>Write 1 to clear PERIPH_BUS_ERR_STATUS.otbn. Always reads 0.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>csrng</ipxact:name>
            <ipxact:description>Write 1 to clear PERIPH_BUS_ERR_STATUS.csrng. Always reads 0.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>edn</ipxact:name>
            <ipxact:description>Write 1 to clear PERIPH_BUS_ERR_STATUS.edn. Always reads 0.</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>wdt</ipxact:name>
            <ipxact:description>Write 1 to clear PERIPH_BUS_ERR_STATUS.wdt. Always reads 0.</ipxact:description>
            <ipxact:bitOffset>6</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>spi</ipxact:name>
            <ipxact:description>Write 1 to clear PERIPH_BUS_ERR_STATUS.spi. Always reads 0.</ipxact:description>
            <ipxact:bitOffset>7</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>SEP_VERSION_ID</ipxact:name>
          <ipxact:addressOffset>'h1000</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>version_id</ipxact:name>
            <ipxact:description>Version ID for the CPU</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'hdeadbeef</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>spi_controller</ipxact:name>
        <ipxact:displayName>SPI Host</ipxact:displayName>
        <ipxact:description>Serial peripheral interface for host mode, suitable for interfacing external serial NOR flash devices</ipxact:description>
        <ipxact:baseAddress>'h10b00000</ipxact:baseAddress>
        <ipxact:range>'h38</ipxact:range>
        <ipxact:width>32</ipxact:width>
        <ipxact:register>
          <ipxact:name>INTR_STATE</ipxact:name>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>ERROR</ipxact:name>
            <ipxact:description>Error-related interrupts, see !!ERROR_ENABLE register for more
information.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPI_EVENT</ipxact:name>
            <ipxact:description>Event-related interrupts, see !!EVENT_ENABLE register for more
information.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_ENABLE</ipxact:name>
          <ipxact:addressOffset>'h4</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>ERROR</ipxact:name>
            <ipxact:description>Enable interrupt when !!INTR_STATE.error is set.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPI_EVENT</ipxact:name>
            <ipxact:description>Enable interrupt when !!INTR_STATE.spi_event is set.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>INTR_TEST</ipxact:name>
          <ipxact:addressOffset>'h8</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>ERROR</ipxact:name>
            <ipxact:description>Write 1 to force !!INTR_STATE.error to 1.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPI_EVENT</ipxact:name>
            <ipxact:description>Write 1 to force !!INTR_STATE.spi_event to 1.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ALERT_TEST</ipxact:name>
          <ipxact:addressOffset>'hc</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>FATAL_FAULT</ipxact:name>
            <ipxact:description>Write 1 to trigger one alert event of this kind.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CONTROL</ipxact:name>
          <ipxact:addressOffset>'h10</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>RX_WATERMARK</ipxact:name>
            <ipxact:description>If !!EVENT_ENABLE.RXWM is set, the IP will send
an interrupt when the depth of the RX FIFO reaches
RX_WATERMARK words (32b each).</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h7f</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>TX_WATERMARK</ipxact:name>
            <ipxact:description>If !!EVENT_ENABLE.TXWM is set, the IP will send
an interrupt when the depth of the TX FIFO drops below
TX_WATERMARK words (32b each).</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>OUTPUT_EN</ipxact:name>
            <ipxact:description>Enable the SPI host output buffers for the sck, csb, and sd lines.  This allows
the SPI_HOST IP to connect to the same bus as other SPI controllers without
interference.</ipxact:description>
            <ipxact:bitOffset>29</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SW_RST</ipxact:name>
            <ipxact:description>Clears the internal state (not registers) to the reset state when set to 1,
including the FIFOs, the CDC's, the core state machine and the shift register.
In the current implementation, the CDC FIFOs are drained not reset.
Therefore software must confirm that both FIFO's empty before releasing
the IP from reset.</ipxact:description>
            <ipxact:bitOffset>30</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPIEN</ipxact:name>
            <ipxact:description>Enables the SPI host.  On reset, this field is 0, meaning
that no transactions can proceed.</ipxact:description>
            <ipxact:bitOffset>31</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>STATUS</ipxact:name>
          <ipxact:addressOffset>'h14</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>TXQD</ipxact:name>
            <ipxact:description>Transmit queue depth.
Indicates how many unsent 32-bit words are currently in the TX FIFO.
When active, this result may be an overestimate due to synchronization delays.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>RXQD</ipxact:name>
            <ipxact:description>Receive queue depth. Indicates how many unread 32-bit words are
currently in the RX FIFO.  When active, this result may an
underestimate due to synchronization delays.</ipxact:description>
            <ipxact:bitOffset>8</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>8</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CMDQD</ipxact:name>
            <ipxact:description>Command queue depth. Indicates how many unread 32-bit words are
currently in the command segment queue.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>RXWM</ipxact:name>
            <ipxact:description>If high, the number of 32-bit words in the RX FIFO is greater
than or equal to !!CONTROL.RX_WATERMARK.</ipxact:description>
            <ipxact:bitOffset>20</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>BYTEORDER</ipxact:name>
            <ipxact:description>The value of the ByteOrder parameter, provided so that firmware
can confirm proper IP configuration. Reads 1 in SEP (ByteOrder = 1);
the listed reset value of 0 holds only for the first clock after
reset.</ipxact:description>
            <ipxact:bitOffset>22</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>RXSTALL</ipxact:name>
            <ipxact:description>If high, signifies that an ongoing transaction has stalled
due to lack of available space in the RX FIFO</ipxact:description>
            <ipxact:bitOffset>23</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>RXEMPTY</ipxact:name>
            <ipxact:description>When high, indicates that the receive fifo is empty.
Any reads from RX FIFO will cause an error interrupt.</ipxact:description>
            <ipxact:bitOffset>24</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>RXFULL</ipxact:name>
            <ipxact:description>When high, indicates that the receive fifo is full.  Any
ongoing transactions will stall until firmware reads some
data from !!RXDATA.</ipxact:description>
            <ipxact:bitOffset>25</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>TXWM</ipxact:name>
            <ipxact:description>If high, the amount of data in the TX FIFO has fallen below the
level of !!CONTROL.TX_WATERMARK words (32b each).</ipxact:description>
            <ipxact:bitOffset>26</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>TXSTALL</ipxact:name>
            <ipxact:description>If high, signifies that an ongoing transaction has stalled
due to lack of data in the TX FIFO</ipxact:description>
            <ipxact:bitOffset>27</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>TXEMPTY</ipxact:name>
            <ipxact:description>When high, indicates that the transmit data fifo is empty.</ipxact:description>
            <ipxact:bitOffset>28</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>TXFULL</ipxact:name>
            <ipxact:description>When high, indicates that the transmit data fifo is full.
Any further writes to !!TXDATA will create an error interrupt.</ipxact:description>
            <ipxact:bitOffset>29</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ACTIVE</ipxact:name>
            <ipxact:description>When high, indicates the SPI host is processing a previously
issued command.</ipxact:description>
            <ipxact:bitOffset>30</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>READY</ipxact:name>
            <ipxact:description>When high, indicates the SPI host is ready to receive
commands. Writing to COMMAND when READY is low is
an error, and will trigger an interrupt.</ipxact:description>
            <ipxact:bitOffset>31</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CONFIGOPTS</ipxact:name>
          <ipxact:addressOffset>'h18</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>CLKDIV</ipxact:name>
            <ipxact:description>Core clock divider.  Slows down subsequent SPI transactions by a
factor of (CLKDIV+1) relative to the core clock frequency.  The
period of sck, T(sck) then becomes `2*(CLK_DIV+1)*T(core)`</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>16</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CSNIDLE</ipxact:name>
            <ipxact:description>Minimum idle time between commands. Indicates the minimum
number of sck half-cycles to hold cs_n high between commands.
Setting this register to zero creates a minimally-wide CS_N-high
pulse of one-half sck cycle.</ipxact:description>
            <ipxact:bitOffset>16</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CSNTRAIL</ipxact:name>
            <ipxact:description>CS_N Trailing Time.  Indicates the number of half sck cycles,
CSNTRAIL+1, to leave between last edge of sck and the rising
edge of cs_n. Setting this register to zero corresponds
to the minimum delay of one-half sck cycle.</ipxact:description>
            <ipxact:bitOffset>20</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CSNLEAD</ipxact:name>
            <ipxact:description>CS_N Leading Time.  Indicates the number of half sck cycles,
CSNLEAD+1, to leave between the falling edge of cs_n and
the first edge of sck.  Setting this register to zero
corresponds to the minimum delay of one-half sck cycle</ipxact:description>
            <ipxact:bitOffset>24</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>FULLCYC</ipxact:name>
            <ipxact:description>Full cycle.  Modifies the CPHA sampling behaviour to allow
for longer device logic setup times.  Rather than sampling the SD
bus a half cycle after shifting out data, the data is sampled
a full cycle after shifting data out.  This means that if
CPHA = 0, data is shifted out on the trailing edge, and
sampled a full cycle later.  If CPHA = 1, data is shifted and
sampled with the trailing edge, also separated by a
full cycle.</ipxact:description>
            <ipxact:bitOffset>29</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CPHA</ipxact:name>
            <ipxact:description>The phase of the sck clock signal relative to the data. When
CPHA = 0, the data changes on the trailing edge of sck
and is typically sampled on the leading edge.  Conversely
if CPHA = 1 high, data lines change on the leading edge of
sck and are typically sampled on the trailing edge.
CPHA should be chosen to match the phase of the selected
device.  The sampling behavior is modified by the
!!CONFIGOPTS.FULLCYC bit.</ipxact:description>
            <ipxact:bitOffset>30</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CPOL</ipxact:name>
            <ipxact:description>The polarity of the sck clock signal.  When CPOL is 0,
sck is low when idle, and emits high pulses.   When CPOL
is 1, sck is high when idle, and emits a series of low
pulses.</ipxact:description>
            <ipxact:bitOffset>31</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>CSID</ipxact:name>
          <ipxact:addressOffset>'h1c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>CSID</ipxact:name>
            <ipxact:description>Chip Select ID</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>COMMAND</ipxact:name>
          <ipxact:addressOffset>'h20</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>CSAAT</ipxact:name>
            <ipxact:description>**C**hip **S**elect **A**ctive **A**fter **T**ransaction.
If !!COMMAND.CSAAT = 0, the chip select line is raised immediately
at the end of the command segment.
If !!COMMAND.CSAAT = 1, the chip select line is left low at the
end of the current transaction segment.
This allows the creation of longer, more complete SPI transactions,
consisting of several separate segments for issuing instructions,
pausing for dummy cycles, and transmitting or receiving data from
the device.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>SPEED</ipxact:name>
            <ipxact:description>The speed for this command segment: &quot;0&quot; = Standard SPI. &quot;1&quot; = Dual SPI.
&quot;2&quot;=Quad SPI,  &quot;3&quot;: RESERVED.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>2</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>DIRECTION</ipxact:name>
            <ipxact:description>The direction for the following command: &quot;0&quot; = Dummy cycles
(no TX/RX). &quot;1&quot; = Rx only, &quot;2&quot; = Tx only, &quot;3&quot; = Bidirectional
Tx/Rx (Standard SPI mode only).</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>2</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>LEN</ipxact:name>
            <ipxact:description>Segment Length.

For read or write segments, this field controls the
number of 1-byte bursts to transmit and or receive in
this command segment.  The number of cycles required
to send or received a byte will depend on !!COMMAND.SPEED.
For dummy segments, (!!COMMAND.DIRECTION == 0), this register
controls the number of dummy cycles to issue.
The number of bytes (or dummy cycles) in the segment will be
equal to !!COMMAND.LEN + 1.</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>20</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ERROR_ENABLE</ipxact:name>
          <ipxact:addressOffset>'h2c</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>CMDBUSY</ipxact:name>
            <ipxact:description>Command Error: If this bit is set, the block sends an error
interrupt whenever a command is issued while busy (i.e. a 1 is
when !!STATUS.READY is not asserted.)</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>OVERFLOW</ipxact:name>
            <ipxact:description>Overflow Errors: If this bit is set, the block sends an
error interrupt whenever the TX FIFO overflows.</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>UNDERFLOW</ipxact:name>
            <ipxact:description>Underflow Errors: If this bit is set, the block sends an
error interrupt whenever there is a read from !!RXDATA
but the RX FIFO is empty.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CMDINVAL</ipxact:name>
            <ipxact:description>Invalid Command Errors: If this bit is set, the block sends an
error interrupt whenever a command is sent with invalid values for
!!COMMAND.SPEED or !!COMMAND.DIRECTION.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CSIDINVAL</ipxact:name>
            <ipxact:description>Invalid CSID: If this bit is set, the block sends an error interrupt whenever
a command is submitted, but CSID exceeds NumCS.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h1</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>ERROR_STATUS</ipxact:name>
          <ipxact:addressOffset>'h30</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>CMDBUSY</ipxact:name>
            <ipxact:description>Indicates a write to !!COMMAND when !!STATUS.READY = 0.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>OVERFLOW</ipxact:name>
            <ipxact:description>Indicates that firmware has overflowed the TX FIFO</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>UNDERFLOW</ipxact:name>
            <ipxact:description>Indicates that firmware has attempted to read from
!!RXDATA when the RX FIFO is empty.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CMDINVAL</ipxact:name>
            <ipxact:description>Indicates an invalid command segment, meaning either an invalid value of
!!COMMAND.SPEED or a request for bidirectional data transfer at dual or quad
speed</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>CSIDINVAL</ipxact:name>
            <ipxact:description>Indicates a command was attempted with an invalid value for !!CSID.</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>ACCESSINVAL</ipxact:name>
            <ipxact:description>Indicates that TLUL attempted to write to TXDATA with no bytes enabled. Such
'zero byte' writes are not supported.</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
            <ipxact:modifiedWriteValue>oneToClear</ipxact:modifiedWriteValue>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>EVENT_ENABLE</ipxact:name>
          <ipxact:addressOffset>'h34</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>RXFULL</ipxact:name>
            <ipxact:description>Assert to send a spi_event interrupt whenever !!STATUS.RXFULL
goes high</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>TXEMPTY</ipxact:name>
            <ipxact:description>Assert to send a spi_event interrupt whenever !!STATUS.TXEMPTY
goes high</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>RXWM</ipxact:name>
            <ipxact:description>Assert to send a spi_event interrupt whenever the number of 32-bit words in
the RX FIFO is greater than or equal to !!CONTROL.RX_WATERMARK. To prevent the
reassertion of this interrupt, read more data from the RX FIFO, or
increase !!CONTROL.RX_WATERMARK.</ipxact:description>
            <ipxact:bitOffset>2</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>TXWM</ipxact:name>
            <ipxact:description>Assert to send a spi_event interrupt whenever the number of 32-bit words in
the TX FIFO is less than !!CONTROL.TX_WATERMARK.  To prevent the
reassertion of this interrupt add more data to the TX FIFO, or
reduce !!CONTROL.TX_WATERMARK.</ipxact:description>
            <ipxact:bitOffset>3</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>READY</ipxact:name>
            <ipxact:description>Assert to send a spi_event interrupt whenever !!STATUS.READY
goes high</ipxact:description>
            <ipxact:bitOffset>4</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>IDLE</ipxact:name>
            <ipxact:description>Assert to send a spi_event interrupt whenever !!STATUS.ACTIVE
goes low</ipxact:description>
            <ipxact:bitOffset>5</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>ap_region</ipxact:name>
        <ipxact:description>Address region whose accesses an output remap redirects.</ipxact:description>
        <ipxact:baseAddress>'h11000000</ipxact:baseAddress>
        <ipxact:range>'h800000</ipxact:range>
        <ipxact:width>64</ipxact:width>
        <ipxact:usage>memory</ipxact:usage>
        <ipxact:access>read-write</ipxact:access>
        <ipxact:register>
          <ipxact:name>mem_array</ipxact:name>
          <ipxact:dim>1048576</ipxact:dim>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>data</ipxact:name>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>64</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>stee_region</ipxact:name>
        <ipxact:description>Address region whose accesses an output remap redirects.</ipxact:description>
        <ipxact:baseAddress>'h11800000</ipxact:baseAddress>
        <ipxact:range>'h800000</ipxact:range>
        <ipxact:width>64</ipxact:width>
        <ipxact:usage>memory</ipxact:usage>
        <ipxact:access>read-write</ipxact:access>
        <ipxact:register>
          <ipxact:name>mem_array</ipxact:name>
          <ipxact:dim>1048576</ipxact:dim>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>data</ipxact:name>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>64</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>sep_external</ipxact:name>
        <ipxact:displayName>SEP External</ipxact:displayName>
        <ipxact:description>SEP external address map (eFuse SHIM control and execute-in-place window).</ipxact:description>
        <ipxact:baseAddress>'h20000000</ipxact:baseAddress>
        <ipxact:range>'h20000000</ipxact:range>
        <ipxact:width>32</ipxact:width>
        <ipxact:registerFile>
          <ipxact:name>efuse_shim_ctrl</ipxact:name>
          <ipxact:displayName>eFuse SHIM Control Model Address Map</ipxact:displayName>
          <ipxact:description>DV model of the eFuse SHIM control interface.</ipxact:description>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:range>'h4</ipxact:range>
          <ipxact:register>
            <ipxact:name>EFUSE_BANK_INIT_TIME</ipxact:name>
            <ipxact:description>eFuse bank initialization time. Number of cycles to wait for the OTP macro to initialize before sensing can begin.</ipxact:description>
