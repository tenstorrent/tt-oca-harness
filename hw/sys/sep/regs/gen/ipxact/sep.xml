            <ipxact:addressOffset>'h0</ipxact:addressOffset>
            <ipxact:size>32</ipxact:size>
            <ipxact:field>
              <ipxact:name>init_time</ipxact:name>
              <ipxact:description>Most OTP have a initialization time before sensing can be done</ipxact:description>
              <ipxact:bitOffset>0</ipxact:bitOffset>
              <ipxact:resets>
                <ipxact:reset>
                  <ipxact:value>'h20</ipxact:value>
                </ipxact:reset>
              </ipxact:resets>
              <ipxact:bitWidth>32</ipxact:bitWidth>
              <ipxact:access>read-write</ipxact:access>
            </ipxact:field>
          </ipxact:register>
        </ipxact:registerFile>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>sep_iccm</ipxact:name>
        <ipxact:description>Tightly coupled instruction SRAM for the SEP CPU.</ipxact:description>
        <ipxact:baseAddress>'hc0000000</ipxact:baseAddress>
        <ipxact:range>'h40000</ipxact:range>
        <ipxact:width>64</ipxact:width>
        <ipxact:usage>memory</ipxact:usage>
        <ipxact:access>read-write</ipxact:access>
        <ipxact:register>
          <ipxact:name>mem_array</ipxact:name>
          <ipxact:dim>32768</ipxact:dim>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>data</ipxact:name>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>64</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>sep_dccm</ipxact:name>
        <ipxact:description>Tightly coupled data SRAM for the SEP CPU.</ipxact:description>
        <ipxact:baseAddress>'hc0040000</ipxact:baseAddress>
        <ipxact:range>'h20000</ipxact:range>
        <ipxact:width>64</ipxact:width>
        <ipxact:usage>memory</ipxact:usage>
        <ipxact:access>read-write</ipxact:access>
        <ipxact:register>
          <ipxact:name>mem_array</ipxact:name>
          <ipxact:dim>16384</ipxact:dim>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>64</ipxact:size>
          <ipxact:field>
            <ipxact:name>data</ipxact:name>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:bitWidth>64</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
      <ipxact:addressBlock>
        <ipxact:name>pic</ipxact:name>
        <ipxact:displayName>EL2_PIC</ipxact:displayName>
        <ipxact:description>VeeR EL2 Programmable Interrupt Controller (PIC) memory-mapped registers.
Supports up to PIC_TOTAL_INT external interrupt sources with 15 priority levels.</ipxact:description>
        <ipxact:baseAddress>'hc0080000</ipxact:baseAddress>
        <ipxact:range>'h5400</ipxact:range>
        <ipxact:width>32</ipxact:width>
        <ipxact:register>
          <ipxact:name>meipl</ipxact:name>
          <ipxact:description>External Interrupt Priority Level Register. Sets the priority level for an interrupt source.</ipxact:description>
          <ipxact:dim>256</ipxact:dim>
          <ipxact:addressOffset>'h0</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>intpriority</ipxact:name>
            <ipxact:description>External interrupt priority level:
RISC-V standard order: 0=Never interrupt, 1..15=Priority (1 lowest, 15 highest)
Reverse order: 15=Never interrupt, 14..0=Priority (14 lowest, 0 highest)</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>4</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>meip</ipxact:name>
          <ipxact:description>External Interrupt Pending Register. Reports pending status of up to 32 interrupt sources.</ipxact:description>
          <ipxact:dim>8</ipxact:dim>
          <ipxact:addressOffset>'h1000</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>intpend</ipxact:name>
            <ipxact:description>External interrupt pending bits. Bit Y indicates pending status for source X*32+Y.
0: Interrupt not pending
1: Interrupt pending</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>32</ipxact:bitWidth>
            <ipxact:volatile>true</ipxact:volatile>
            <ipxact:access>read-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>meie</ipxact:name>
          <ipxact:description>External Interrupt Enable Register. Controls interrupt enable for a single source.</ipxact:description>
          <ipxact:dim>256</ipxact:dim>
          <ipxact:addressOffset>'h2000</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>inten</ipxact:name>
            <ipxact:description>External interrupt enable:
0: Interrupt disabled
1: Interrupt enabled</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>mpiccfg</ipxact:name>
          <ipxact:description>PIC Configuration Register. Used to select the operational parameters of the PIC.</ipxact:description>
          <ipxact:addressOffset>'h3000</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>priord</ipxact:name>
            <ipxact:description>Priority order:
0: RISC-V standard compliant priority order (0=lowest to 15=highest)
1: Reverse priority order (15=lowest to 0=highest)</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>meigwctrl</ipxact:name>
          <ipxact:description>External Interrupt Gateway Configuration Register. Controls interrupt type and polarity.</ipxact:description>
          <ipxact:dim>256</ipxact:dim>
          <ipxact:addressOffset>'h4000</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>polarity</ipxact:name>
            <ipxact:description>External interrupt polarity:
0: Active-high interrupt
1: Active-low interrupt</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
          <ipxact:field>
            <ipxact:name>irq_type</ipxact:name>
            <ipxact:description>External interrupt type:
0: Level-triggered interrupt
1: Edge-triggered interrupt</ipxact:description>
            <ipxact:bitOffset>1</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>read-write</ipxact:access>
          </ipxact:field>
        </ipxact:register>
        <ipxact:register>
          <ipxact:name>meigwclr</ipxact:name>
          <ipxact:description>External Interrupt Gateway Clear Register. Writing any value clears the gateway's
interrupt pending (IP) bit for edge-triggered interrupts.</ipxact:description>
          <ipxact:dim>256</ipxact:dim>
          <ipxact:addressOffset>'h5000</ipxact:addressOffset>
          <ipxact:size>32</ipxact:size>
          <ipxact:field>
            <ipxact:name>clear</ipxact:name>
            <ipxact:description>Write any value to clear the interrupt pending bit in the gateway.
This register is write-only; reads return 0.</ipxact:description>
            <ipxact:bitOffset>0</ipxact:bitOffset>
            <ipxact:resets>
              <ipxact:reset>
                <ipxact:value>'h0</ipxact:value>
              </ipxact:reset>
            </ipxact:resets>
            <ipxact:bitWidth>1</ipxact:bitWidth>
            <ipxact:access>write-only</ipxact:access>
          </ipxact:field>
        </ipxact:register>
      </ipxact:addressBlock>
    </ipxact:memoryMap>
  </ipxact:memoryMaps>
</ipxact:component>
