# smc_top: IP-XACT component
VLNV tenstorrent.com:ocah:smc_top:1.0

## Address spaces and blocks
smc_top.smc_cluster_core0_wdt: base 'hc0000000, range 'h24, width 32
smc_top.smc_cluster_core1_wdt: base 'hc0000400, range 'h24, width 32
smc_top.smc_cluster_core2_wdt: base 'hc0000800, range 'h24, width 32
smc_top.smc_cluster_core3_wdt: base 'hc0000c00, range 'h24, width 32
smc_top.debug_module: base 'hc0001000, range 'h868, width 32
smc_top.smc_reset_unit: base 'hc0002000, range 'hcc, width 32
smc_top.smc_misc_wrap: base 'hc0002800, range 'h20c, width 32
smc_top.gpio_intf_wrap: base 'hc0003000, range 'h430, width 32
smc_top.smc_avsbus_controller: base 'hc0004000, range 'h5c, width 32
smc_top.smc_i2c_wrap: base 'hc0005000, range 'he0c, width 32
smc_top.smc_uart_wrap: base 'hc0006000, range 'h1000, width 64
smc_top.smc_efuse_map: base 'hc0007000, range 'h100, width 256
smc_top.efuse_interface_ctrl: base 'hc0008000, range 'h24, width 32
smc_top.smc_telemetry_receiver_wrap: base 'hc0009000, range 'h300, width 32
smc_top.smc_system_timer_octs: base 'hc000a000, range 'h24, width 32
smc_top.dtp_ctrl_reg: base 'hc000b000, range 'h800, width 32, memory
smc_top.dfx_ctrl: base 'hc000b800, range 'h18, width 64
smc_top.smc_pwm: base 'hc000c000, range 'h804, width 32
smc_top.smc_base_config: base 'hc0010000, range 'h4c, width 64
smc_top.smc_alias_remap_wrap: base 'hc0012000, range 'h100, width 64
smc_top.smc_mmode_remap_wrap: base 'hc0013000, range 'h40, width 64
smc_top.smc_xvisor_remap_wrap: base 'hc0014000, range 'h40, width 64
smc_top.smc_inbound_filter_ctrl_wrap: base 'hc0015000, range 'h200, width 64
smc_top.smc_outbound_filter_ctrl_wrap: base 'hc0016000, range 'h200, width 64
smc_top.smc_mailbox: base 'hc0018000, range 'h1f850, width 64
smc_top.dma_ctrl: base 'hc0038000, range 'h138, width 32
smc_top.zeroer_ctrl: base 'hc0038200, range 'h18, width 64
smc_top.smc_cpu_ctrl: base 'hc0039000, range 'h2c0, width 64
smc_top.oca_i3c_wrap: base 'hc003a000, range 'h6000, width 32
smc_top.spm_rom_memory: base 'hc0040000, range 'h20000, width 64, memory
smc_top.spm_memory: base 'hc0060000, range 'h100000, width 64, memory
smc_top.smc_cla: base 'hc0160000, range 'h4000, width 64
smc_top.smc_external: base 'hc0400000, range 'hb000, width 32
smc_top.mmode_region: base 'hc1000000, range 'h800000, width 64, memory
smc_top.xvisor_region: base 'hc1800000, range 'h800000, width 64, memory
smc_top.smc_cluster_plic: base 'hc4000000, range 'h207008, width 32
smc_top.smc_cluster_clint: base 'hc8000000, range 'hc000, width 64
smc_top.smc_cluster_core0_beu: base 'hc8010000, range 'h30, width 64
smc_top.smc_cluster_core1_beu: base 'hc8011000, range 'h30, width 64
smc_top.smc_cluster_core2_beu: base 'hc8012000, range 'h30, width 64
smc_top.smc_cluster_core3_beu: base 'hc8013000, range 'h30, width 64
smc_top.smc_cluster_error_device: base 'hc8014000, range 'h1000, width 32, memory

## Registers
Registers are 64-bit, read-write, reset 0x0 unless marked. A register's access mark holds for its fields unless they carry their own. Offsets are from the block's base; lines under a group give offsets from that group; [hi:lo] are bit positions; {n}, {i} and the like mark numbered series; 'fields as' and 'values as' point back to an identical list; <NAME> marks a mode.

## smc_top.smc_cluster_core0_wdt — Watchdog timer configuration, counter, compare, and feed and key registers. A write takes effect only if its byte enables cover all four bytes of COUNT, COUNT_HI, FEED or KEY, or bytes 0 and 1 of SCALED_COUNT or CMP; each CTRL byte is written on its own. Any other write returns OKAY and changes nothing, not even the lock. Each effective write to a register other than KEY locks the watchdog, and changes no field if it was already locked. A 64-bit write at 0x18 writes FEED and KEY together and leaves the watchdog locked.
Base 0xC0000000
Same registers: smc_top.smc_cluster_core1_wdt 0xC0000400, smc_top.smc_cluster_core2_wdt 0xC0000800, smc_top.smc_cluster_core3_wdt 0xC0000C00
0x00 CTRL 32-bit access per field — KEY reg must be written to before any other register in this addrmap can be written to, unlocking the WDT. After writing to another register, the WDT will be locked again, and KEY must be written to again to unlock it.
  [28] wdogip0 rw — Pending interrupt. Hardware sets this bit on every cycle the scaled count has reached the compare value. To clear it, write KEY and then write 0 to this bit while the scaled count is below the compare value. Writing FEED does not clear it.
  [13] wdogcoreawake rw — Enable WDT to only count when the core is not in reset
  [12] wdogenalways rw — Enable WDT to always count. This has priority over wdogcoreawake. With this field and wdogcoreawake both clear, COUNT does not increment and holds its value.
  [9] wdogzerocmp rw — Enable cycle counter to be reset to 0 when compare value has been reached
  [8] wdogrsten rw — Enables a sticky reset signal to outputted to top level, can be used for a second stage wdt
  [3:0] wdogscale rw — WDT counter scale value. Scales the current cycle count (time) by count / 2 ^ wdogscale value
0x08 COUNT 32-bit
  [30:0] wdogcount — 31 bit wdt counter registers. On write, the counter will be set to the written value, then continue counting up. KEY reg must be written to before any other register in this addrmap can be written to, unlocking the WDT. After writing to another register, the WDT will be locked again, and KEY must be written to again to unlock it.
0x0C COUNT_HI 32-bit wo
  [31:0] wdogcounthi — Upper word of the counter. The counter is 31 bits wide and lies entirely in COUNT, so this register has no storage and reads 0. A write covering all four bytes leaves the counter unchanged but locks the WDT, so KEY must be written again before the next write.
0x10 SCALED_COUNT 32-bit
  [15:0] wdogs — Scaled value of wdt counter. (i.e. count >> wdogscale). Writing to this reg has no effect, but will lock the WDT (meaning KEY must be written to KEY reg to unlock it again). KEY reg must be written to before any other register in this addrmap can be written to, unlocking the WDT. After writing to another register, the WDT will be locked again, and KEY must be written to again to unlock it.
0x18 FEED 32-bit
  [31:0] wdogfeed — Feed register. Writing 0xD09F00D will reset the counter value back to 0. Feeding does not clear CTRL.wdogip0. KEY reg must be written to before any other register in this addrmap can be written to, unlocking the WDT. After writing to another register, the WDT will be locked again, and KEY must be written to again to unlock it.
0x1C KEY 32-bit
  [31:0] wdogkey — Key register. Magic key (0x51F15E) must be written to this register before a write to any other register in this addrmap. Must be written every time. Reading this reg returns 1 if key has been written to it and it is unlocked, 0 otherwise.
0x20 CMP 32-bit reset 0x1000
  [15:0] wdogcmp0 — Compare register. Value that gets compared to wdogs. KEY reg must be written to before any other register in this addrmap can be written to, unlocking the WDT. After writing to another register, the WDT will be locked again, and KEY must be written to again to unlock it.

## smc_top.debug_module — Memory region through which a hart in Debug Mode exchanges state with the Debug Module: handshake mailboxes, generated instructions, program buffer, data registers, per-hart flags and the debug ROM. Only the harts of the CPU cluster reach this region; SMC bus initiators outside the cluster do not. The debugger-facing Debug Module registers (dmcontrol, dmstatus, abstractcs, sbcs, ...) are reached over the Debug Module Interface and do not appear in this map.
Base 0xC0001000
0x100 HALTED 32-bit wo reset not defined
  [9:0] hartid — Debug ROM causes the hart to write its hart ID here when it is in Debug Mode.
0x104 GOING 32-bit wo reset not defined
  [9:0] hartid — Debug ROM causes the hart to write 0 here when it begins executing Debug Mode instructions.
0x108 RESUMING 32-bit wo reset not defined
  [9:0] hartid — Debug ROM causes the hart to write its hart ID here when it leaves Debug Mode.
0x10C EXCEPTION 32-bit wo reset not defined
  [9:0] hartid — Debug ROM causes the hart to write 0 here if it takes an exception in Debug Mode.
0x300 WHERETO 32-bit ro reset not defined
  [31:0] instr — Jump instruction filled in by the Debug Module to direct the hart in Debug Mode.
{0x328+4i} ABSTRACT[{i}] (i=0..4) 32-bit ro reset not defined
  [31:0] instr — Instruction generated by the Debug Module for the current abstract command.
{0x33C+4i} PROGBUF[{i}] (i=0..15) 32-bit
  [31:0] data — Program buffer word shared with the debugger. Byte accesses are supported.
0x37C IMPEBREAK 32-bit ro reset 0x100073
  [31:0] instr — Implicit EBREAK instruction following the program buffer.
{0x380+4i} DATA[{i}] (i=0..3) 32-bit
  [31:0] data — Abstract command data word shared with the debugger. Byte accesses are supported.
0x400 FLAGS 32-bit ro reset not defined — One flag byte per hart, at byte offset equal to the hart ID. Bit 0 is go (execute the command at WHERETO); bit 1 is resume (leave Debug Mode). Bits 7:2 read as 0.
  [8n+7:8n] flags_{n} (n=0..3) — Hart {n} go/resume flags.
{0x800+4i} ROM[{i}] (i=0..25) 32-bit ro reset not defined
  [31:0] data — Debug ROM word. Holds the fixed Debug Mode entry, exception and resume handlers.

## smc_top.smc_reset_unit — Subsystem reset control, hold and isolation controls, and reset-sequencing status registers.
Base 0xC0002000
0x20 SS_CONFIG 32-bit
  [31:0] ss_config — Configuration registers to setup system configuration. Usage is integration-specific; see the adopter chiplet specification.
0x24 SS_CONFIG_LOCK 32-bit
  [31:0] config_lock write-1-sets — Written to lock down SS config. If bit 0 is written, then bit 0 of other SS config cannot be written to again
0x40 SS_COLD_RESET_N 32-bit
  [31:0] reset_n_n0_scan — Subsystem active low cold resets
0x44 SS_WARM_RESET_N 32-bit reset 0xFFFFFFFF
  [31:0] reset_n_n0_scan — Subsystem active low warm resets
0x48 SS_CONFIG_HOLD 32-bit
  [31:0] configuration_state_hold — Used with warm_reset_n. Asserting ensures all registers configured during boot, including fuse values for export compliance, SRAM repair, other fuse values, etc. are preserved
0x4C SS_SRAM_HOLD 32-bit
  [31:0] sram_hold — Used with warm_reset_n. Asserting ensures SRAMs, latch arrays and anything else that MBIST is used to test and initialize during cold reset are preserved
0x50 SS_CRITICAL_HOLD 32-bit
  [31:0] critical_signal_hold — Used with warm_reset_n. Asserting ensures security, RAS, NMIs, perf counters, debug/trace and other subsystem specific registers are preserved
0x54 SS_DEBUG_HOLD 32-bit
  [31:0] debug_hold — Used with warm_reset_n. Debug hold signal to ensure any debug registers are preserved
0x60 SS_RESET_COMPLETE 32-bit ro
  [31:0] reset_complete — Response signal from subsystem to indicate reset (or some other critical step) has completed. Each bit reads the synchronized live value of its subsystem's signal; it is not latched.
0x70 SS_COLD_RESET_LOCK 32-bit
  [31:0] cold_reset_lock write-1-sets — Written to lock down SS cold reset. If bit 0 is written, then bit 0 of other SS cold reset cannot be written to again
0x80 SS_FORCE_TO_REF_CLK 32-bit
  [31:0] force_ss_to_ref_clk_n — Forces clock to be ref clk. The ensures reset reaches all FFs within a subsystem in same clock cycle
0xA8 SYNC_REG 32-bit
  [0] sync — Set to assert global sync bit
0xB0 ISOLATE_REQ_REG 32-bit
  [31:0] isolate_req_reg — Isolate request. This prevents reset from being propagated to SS, keeping them alive in case of a cold reset
0xB4 ISOLATE_REQ_PINEN_REG 32-bit
  [31:0] isolate_req_pinen_reg — Isolate request pin enable. This enables the external isolate request pin to have an effect on ss isolate requests
0xB8 ISOLATE_REQ_SMC_REG 32-bit
  [0] isolate_req_smc_reg write-1-clears — Isolate request smc. Set by a rising edge of cfg_flr_pf_active; software writes 1 to clear. A write of 0, or a write whose byte strobes do not select this field, leaves it unchanged; a rising edge in the same cycle as a clearing write wins.
0xBC ISOLATE_REQ_SMCEN_REG 32-bit
  [31:0] isolate_req_smcen_reg — Isolate request smc enable. This enables the FLR lock to have an effect on ss isolate requests
0xC0 ISOLATE_REQ_VIS 32-bit ro reset 0x111
  [8] cool_reset_n_o — Visibility bit for cool reset output
  [4] cool_reset_n_i — Visibility bit for cool reset input
  [0] isolate_req_pin — Visibility bit for isolate request pin
0xC4 ISOLATE_REQ_FLR_COUNTER_VALUE 32-bit
  [31:0] isolate_req_flr_counter_value — Number of cycles post cfg_flr_pf_active assertion is waited until cool_reset_n is asserted
0xC8 ISOLATE_REQ_FLR_RESET_COUNTER_VALUE 32-bit
  [31:0] isolate_req_flr_reset_counter_value — Number of cycles cool_reset_n is asserted for. NOTE: The cool reset flow requires this value to be greater than 0; a value of 0 will prevent initiation, regardless of ISOLATE_REQ_FLR_COUNTER_VALUE's value

## smc_top.smc_misc_wrap — Aggregates the SMC scratch, chip-configuration, and NDM-reset register blocks.
Base 0xC0002800
0x00 scratch_cold group — General-purpose scratch register bank.
  {0x0+4j} SCRATCH[{j}] (j=0..7) 32-bit
    [31:0] data — Scratch register
0x80 scratch_cold_warm group — General-purpose scratch register bank.
  {0x0+4j} SCRATCH[{j}] (j=0..7) 32-bit
    [31:0] data — Scratch register
0x100 chip_config group — Chip version, identification, and lifecycle-state registers.
  0x00 VERSION_LO 32-bit ro reset 0x100A0
    [31:0] version_lo — SMC version identifier, lower 32 bits, set by eight metal-programmable revision cells, one byte per cell, so a metal-only respin can change it. The register has no storage: a read returns the cell values, and the reset value is the version the cells are tied to.
  0x04 VERSION_HI 32-bit ro
    [31:0] version_hi — SMC version identifier, upper 32 bits, set by eight metal-programmable revision cells, one byte per cell, so a metal-only respin can change it. The register has no storage: a read returns the cell values, and the reset value is the version the cells are tied to.
  0x08 CHIP_ID 32-bit ro
    [31:0] chip_id — Chip ID, a constant fixed when the SMC is integrated, not read from fuses (e.g. 0 = Memory, 1 = CPU, 2 = AI Compute, 3 = Ethernet). The register has no storage: a read returns that constant, and the reset value is the default constant.
  0x0C LC_STATE 32-bit ro reset 0xF
    [7:0] lc_state — Lifecycle state from SEP, differentially encoded: {~raw[3:0], raw[3:0]}. The register has no storage: each read returns the value SEP drives at that moment, neither latched nor decoded. The reset value 0x0F is the INVALID encoding 4'b1111, the fail-safe state, and is what SEP itself drives until fuse sensing completes. An SMU built without SEP drives 0xF0 (TEST_DEV).
0x200 ndm_reset group — Per-cluster NDM reset handshake with an external CPU cluster debug module
  0x00 NDMRESET_REQUEST 32-bit ro
    [31:0] ndmreset_request — Bit i is the NDM reset request from external CPU cluster i. Bits below ndmreset_cluster_count follow the request input. Bits at and above that count read as 0. The field holds up to 32 clusters.
  0x04 NDMRESET_PROCESS 32-bit
    [31:0] ndmreset_process — Bit i is the firmware response to the NDM reset request from external CPU cluster i. Bits below ndmreset_cluster_count are driven on the process output. Bits at and above that count are stored and are not driven. The field holds up to 32 clusters.
  0x08 NDMRESET_CLUSTER_COUNT 32-bit ro
    [7:0] ndmreset_cluster_count — Number of external CPU clusters connected on the low bits of NDMRESET_REQUEST and NDMRESET_PROCESS. Software masks those registers with this value. The maximum is 32.

## smc_top.gpio_intf_wrap — Wrapper address map instantiating one GPIO interface register block per pad.
Base 0xC0003000
{0x0+0x10*i} gpio_intf[{i}] (i=0..66) group — GPIO interface configuration: pad/core routing, receive and transmit enables, and interrupt control.
  0x00 DATA_CTRL 32-bit access per field
    [31] pad2core ro — PAD2SOC Value
    [25] lsio_enable ro — LSIO hardware request status. Set while lsio_interface_select_i is asserted and lsio_disable is clear. Because the hardware LSIO request outranks interface_enable, a set value also means the LSIO plane is driving this pad's data and direction. This field does not reflect a software-forced selection via lsio_select, which ranks below the register interface - it reads 0 in that case even when LSIO drives the pad.
    [21:20] interrupt_type rw — Interrupt type - 0: active-high level, 1: active-low level, 2: rising edge, 3: falling edge
    [19] lsio_disable rw — When set, LSIO accesses will be blocked from the GPIO interface
    [18] interrupt_enable rw
    [17] lsio_select rw — Force the LSIO interface to be used from software, when no hardware LSIO request is present on this pad. interface_enable has higher priority over this bit. This ranking applies to this software force bit only: the hardware lsio_interface_select_i input outranks interface_enable. Use lsio_disable to gate both.
    [16] interface_enable rw — Register Interface Enable. Setting this chooses register values to drive the PAD. This includes core2pad, enable_rx_tx, and pad2core
    [5:4] enable_rx_tx rw — Direction control. 2'b00: Neither RX nor TX enabled. 2'b01: TX enabled. 2'b10: RX enabled. 2'b11: Both enabled
    [0] core2pad rw — Register-driven data to send to the pad.
  0x04 DATA_CTRL_ENABLE 32-bit
    [5] use_reg_rx — Per-field register override. When set, the RX direction (input enable) is taken from enable_rx_tx[1]. OR'd with interface_enable.
    [4] use_reg_tx — Per-field register override. When set, the TX direction (output enable) is taken from enable_rx_tx[0]. OR'd with interface_enable.
    [0] use_reg_core2pad — Per-field register override. When set, core2pad is register-driven. OR'd with interface_enable.
  0x08 ACCESS_FILTER 32-bit reset 0x10100 — GPIO Access Filter Register. WARNING: please read back this register to ensure the filter was written correctly. If you do not do so the filter may not update before your next transaction, causing unexpected behavior.
    [18:16] arprot_requirement — When read_filter_enable is set, only allow read accesses with this prot value WARNING: please read back this register to ensure the filter was written correctly. If you do not do so the filter may not update before your next transaction, causing unexpected behavior.
    [10:8] awprot_requirement — When write_filter_enable is set, only allow write accesses with this prot value WARNING: please read back this register to ensure the filter was written correctly. If you do not do so the filter may not update before your next transaction, causing unexpected behavior.
    [1] read_filter_enable — Read Filter Enable. When set, reads require an exact match between AXI ARPROT and arprot_requirement. When clear, reads are unfiltered. PROT does not identify the initiator. WARNING: please read back this register to ensure the filter was written correctly. If you do not do so the filter may not update before your next transaction, causing unexpected behavior.
    [0] write_filter_enable — Write Filter Enable. When set, writes require an exact match between AXI AWPROT and awprot_requirement. When clear, writes are unfiltered. PROT does not identify the initiator. WARNING: please read back this register to ensure the filter was written correctly. If you do not do so the filter may not update before your next transaction, causing unexpected behavior.

## smc_top.smc_avsbus_controller — Command, readback, status, and interrupt registers for the AVSBus (PMBus V1.3 Part III) controller.
Base 0xC0004000
0x00 AVS_CMD 32-bit wo — The command+data to be transferred to the AVS bus
  [29:28] R_OR_W — Read or write type: [list] [*]0x0 - Commit Write [*]0x1 - Hold Write [*]0x2 - Reserved [*]0x3 - Read [/list]
  [27] CMD_GRP — Command group: Set to 1 for manufacturer-specific Command Code (cmd_code), otherwise 0
  [26:23] CMD_CODE — Command Code (For cmd_group=0. For cmd_group=1, this is manufacturer-specific): [list] [*]0x0 - Target Rail Voltage Read/Write [*]0x1 - Vout Transition Rate Read/Write [*]0x2 - Rail Current Read [*]0x3 - Temperature Read [*]0x4 - Force Voltage Reset (Requires wr_cmd_data=0x0) [*]0x5 - Power Mode Read/Write [*]0xe - AVSBus Status Read/Write [*]0xf - AVSBus Version Read [/list]
  [22:19] RAIL_SEL — Rail Select: 0x0 - Rail 0 0x1 - Rail 1 0xf - Broadcast
  [18:3] CMD_DATA — Write Cmd Data. Formats: [list] [*]Voltage (cmd_code 0x0): 16-bit unsigned int, 1LSB=1mV [*]Transition Rate (cmd_code 0x1): [list] [*]MSByte: Rise Rate, 8-bit unsigned int, 1LSB=1mV/us [*]LSByte: Fall Rate, 8-bit unsigned int, 1LSB=1mV/us [/list] [*]Reset Voltage (cmd_code 0x4): 16-bits, all zeroes [*]Power Mode (cmd_code 0x5): 3-bits, LSB aligned: [list] [*]0x0 - Maximum Efficiency [*]0x3 - Maximum Power [*]0x4-0x7 - Manufacturer-specific [/list] [*]AVSBus Status (cmd_code 0xe): 16-bits, encoded per AVS Spec [*]AVSBus Version (cmd_code 0xf): 4 bits encoded per AVS Spec, LSB-aligned [*]For read cmd_code's, this is 0xffff [/list]
0x04 AVS_READBACK 32-bit ro — Response data from AVS slave device (updated in response to both AVS read and write commands). Reading this register causes the AVS response readback fifo pointer to advance.
  [31:30] SLAVE_ACK read-modifies — Indicates whether command executed or not - codes 0x1 and 0x2 trigger automatic retries by hardware: [list] [*]0x0: Action Performed [*]0x1: Good CRC received but resource unavailable - hardware will retry [*]0x2: Bad CRC received - hardware will retry [*]0x3: Good CRC received but bad data, data type or selector - no hardware retry [/list]
  [29] CONST0 read-modifies — Frame-valid bit of the slave response sub-frame: 0 in a valid frame, 1 when the slave did not respond
  [28:24] STATUS_RESPONSE read-modifies — 5-bit field indicating general condition of the slave, per AVS spec StatusReponse field: [list] [*]bit 4: VDone - AND of all VDone bits of active rails [*]bit 3: StatusAlert - Indicates potential status issue, requiring AVSBus Status read cmd for details [*]bit 2: AVS_Control - 1 if ABSBus is controlling at least 1 device output, 0 otherwise. [*]bit 1: MfrSpcfc_Stts1 - Manufacturer-specific [*]bit 0: MfrSpcfc_Stts2 - Manufacturer-specific [/list]
  [23:8] CMD_DATA read-modifies — Read Cmd Data. Format depends on cmd_code in previous master subframe:[list] [*]Voltage (cmd_code 0x0): 16-bit unsigned int, 1LSB=1mV [*]Transition Rate (cmd_code 0x1): [list] [*]MSByte: Rise Rate, 8-bit unsigned int, 1LSB=1mV/us [*]LSByte: Fall Rate, 8-bit unsigned int, 1LSB=1mV/us [/list] [*]Current (cmd_mode 0x2): 16-bit unsigned, 1LSB=10mA [*]Temperature (cmd_code 0x3): 16-bit signed, 1LSB=0.1degC [*]Power Mode (cmd_code 0x5): 3-bits, LSB aligned: [list] [*]0x0 - Maximum Efficiency [*]0x3 - Maximum Power [*]0x4-0x7 - Manufacturer-specific [/list] [*]AVSBus Status (cmd_code 0xe): 16-bits, encoded per AVS Spec [*]AVSBus Version (cmd_code 0xf): 4 bits encoded per AVS Spec, LSB-aligned [*]If master issued a write (rw!=0x3) in previous master subframe, this field is 0xffff [/list]
  [2:0] CRC read-modifies — The CRC-3 code received from slave
0x08 AVS_DEBUG_READBACK 32-bit ro reset 0xFFFFFFFF — This register mirrors the AVS_READBACK register, but reading it does NOT affect the AVS readback fifo pointer. Provided for debug purposes.
  [31:0] AVS_SLAVE_SUBFRAME — The current top-of-fifo AVS slave response sub-frame in the readback fifo
0x0C AVS_LATEST_SLAVE_SUBFRAME 32-bit ro — This register contains the most recently received subframe from the AVS slave, bypassing the AVS readback fifo. It is provided so that APB can see the current slave StatusResponse and SlaveAck settings in a timely fashion, since the status data from the next entry in the readback fifo might have considerable latency relative to when it was initially received from the AVS Slave.
  [31:0] AVS_SLAVE_SUBFRAME — The most recently received AVS slave response sub-frame
0x20 AVS_NORMAL_STATUS 32-bit ro — Various Status bits indicating normal operating conditions for APB2AVS bridge block. These all have corresponding maskable bits in the AVS_INTERRUPT register
  [22] AVS_SLAVE_IS_IN_RESYNC — Indicates that the AVS master is issuing a slave resync operation (35 AVS clock cycles of holding mdata high)
  [21] AVS_BUS_IS_IDLE — Indicates that neither AVS master nor slave is currently driving a transaction on the AVS bus
  [20] READBACK_HAS_DATA — Indicates AVS_READBACK register has data ready to read on APB
  [19] READBACK_FIFO_FULL — Indicates read-back fifo is full - no new AVS commands will be launched until space is freed by an AVS_READBACK access
  [18] CMD_FIFO_FULL — Indicates AVS_CMD fifo is full - any additional APB writes to AVS_CMD will be dropped until the AVS bus can accept the next command, thus freeing space in the cmd fifo
  [17] CMD_FIFO_EMPTY — Indicates AVS_CMD fifo is empty
  [16] AVS_MASTER_IS_RETRYING — Master is currently in the middle of retrying a failed command
  [15:0] TOTAL_RETRIES — Total number of retries attempted by the AVS Master
0x24 AVS_SLAVE_STATUS 32-bit ro — Contains the most recent status feedback from the AVS slave device
  [17:16] AVS_SLAVE_ACK — The SlaveAck bits of the most recent slave subframe received: [list] [*]00: Action Performed [*]01:Good CRC received by resource unavailable. No action performed (triggers retry) [*]10: Bad CRC received (triggers retry) [*]11: Good CRC received bit bad data, data type, or selector. No action performed [/list]
  [4:0] AVS_SLAVE_STATUS_RESPONSE — The 5-bit Slave StatusResponse of the most recent slave subframe received, indicating the general condition of the slave, per AVS spec StatusReponse field: [list] [*]bit 4: VDone - AND of all VDone bits of active rails [*]bit 3: StatusAlert - Indicates potential status issue, requiring AVSBus Status read cmd for details [*]bit 2: AVS_Control - 1 if ABSBus is controlling at least 1 device output, 0 otherwise. [*]bit 1: MfrSpcfc_Stts1 - Manufacturer-specific [*]bit 0: MfrSpcfc_Stts2 - Manufacturer-specific [/list]
0x28 AVS_FIFOS_STATUS 32-bit ro reset 0x8000800 — Contains the number of occupied and vacant slots in the AVS master's command and readback FIFOs
  [27:24] READBACK_FIFO_VACANT_SLOTS — Number of vacant slots in the readback FIFO. The field has no storage; with the FIFO empty after reset it reads the READBACK_FIFO_DEPTH parameter, 8 by default, and the reset value is that default. The 4-bit field holds depths up to 15.
  [19:16] READBACK_FIFO_OCCUPIED_SLOTS — Number of occupied slots in the readback FIFO
  [11:8] CMD_FIFO_VACANT_SLOTS — Number of vacant slots in the command FIFO. The field has no storage; with the FIFO empty after reset it reads the COMMAND_FIFO_DEPTH parameter, 8 by default, and the reset value is that default. The 4-bit field holds depths up to 15.
  [3:0] CMD_FIFO_OCCUPIED_SLOTS — Number of occupied slots in the command FIFO
0x30 AVS_INTERRUPT 32-bit ro — Interrupt register - A '1' indicates an interrupt has occurred for that bit. To clear the interrupt bit, write to the corresponding field in the AVS_INTERRUPT_CLEAR register.
  [8] READBACK_OVERFLOW_INT — Indicates that the response from AVS slave could not be written to readback FIFO due to it being full => response was dropped
  [7] READBACK_UNDERFLOW_INT — Indicates that an APB read on the AVS_READBACK reg occurred when the readback fifo was empty (AVS_NORMAL_STATUS:readback_has_data=0)
  [6] CMD_FIFO_OVERFLOW_INT — Indicates that an APB write to AVS_CMD was attempted when the the command fifo was already full - the command is dropped
  [5] MAX_RETRIES_ATTEMPTED_INT — Indicates that the AVS Master failed to receive a non-failure acknowledgement from the Slave after a command was retried the maximum allowable number of times (as determined by AVS_CFG_0:max_retries)
  [4] SLAVE_UNRESPONSIVE_INT — Indicates the AVS Slave device is not responding to command subframes from the Master
  [3] READBACK_HAS_DATA_INT — Indicates AVS_READBACK register has data ready to read on APB
  [2] READBACK_FIFO_FULL_INT — Indicates read-back fifo is full - no new AVS commands will be launched until space is freed by an AVS_READBACK access
  [1] CMD_FIFO_FULL_INT — Indicates AVS_CMD fifo is full - any additional APB writes to AVS_CMD will be dropped until the AVS bus can accept the next command, thus freeing space in the cmd fifo
  [0] AVS_SLAVE_ISSUED_INTERRUPT — Indicates the AVS slave has signaled an interrupt
0x34 AVS_INTERRUPT_MASK 32-bit reset 0x1FF — Interrupt mask register - Determines which AVS_INTERRUPT bits can trigger an interrupt
  [8] DISABLE_READBACK_OVERFLOW_INT — Disable readback_overflow interrupt
  [7] DISABLE_READBACK_UNDERFLOW_INT — Disable readback_underflow interrupt
  [6] DISABLE_CMD_FIFO_OVERFLOW_INT — Disable cmd_fifo_overflow interrupt
  [5] DISABLE_MAX_RETRIES_ATTEMPTED_INT — Disable max_retries_attempted interrupt
  [4] DISABLE_SLAVE_UNRESPONSIVE_INT — Disable slave_unresponsive interrupt
  [3] DISABLE_READBACK_HAS_DATA_INT — Disable readback_has_data interrupt
  [2] DISABLE_READBACK_FIFO_FULL_INT — Disable readback_fifo_full interrupt
  [1] DISABLE_CMD_FIFO_FULL_INT — Disable cmd_fifo_full interrupt
  [0] DISABLE_AVS_SLAVE_ISSUED_INTERRUPT — Disable notification of AVS slave interrupt
0x38 AVS_INTERRUPT_CLEAR 32-bit wo — Write 1 to clear corresponding interrupt bit
  [8] CLEAR_READBACK_OVERFLOW_INT — Clear readback_overflow interrupt
  [7] CLEAR_READBACK_UNDERFLOW_INT — Clear readback_underflow interrupt
  [6] CLEAR_CMD_FIFO_OVERFLOW_INT — Clear cmd_fifo_overflow interrupt
  [5] CLEAR_MAX_RETRIES_ATTEMPTED_INT — Clear max_retries_attempted interrupt
  [4] CLEAR_SLAVE_UNRESPONSIVE_INT — Clear slave_unresponsive interrupt
  [3] CLEAR_READBACK_HAS_DATA_INT — Clear readback_has_data interrupt
  [2] CLEAR_READBACK_FIFO_FULL_INT — Clear readback_fifo_full interrupt
  [1] CLEAR_CMD_FIFO_FULL_INT — Clear cmd_fifo_full interrupt
  [0] CLEAR_AVS_SLAVE_ISSUED_INTERRUPT
0x50 AVS_CFG_0 32-bit reset 0x51000 — Configuration register for APB2AVS bridge block
  [23:16] MAX_RETRIES — Maximum number of retries, after the original attempt, if an AVS command returns a fail status (either due to targeted resource being busy or CRC failure). A value of 0 disables retries and MAX_RETRIES_ATTEMPTED_INT.
  [15:0] RESYNC_INTERVAL — Interval between periodic slave resync operations on the AVS bus, in APB clock cycles counted from the end of the previous resync. The resulting request then crosses a 3-stage AVS clock synchronizer, and the resync starts once any frame in flight has completed.
0x54 AVS_CFG_1 32-bit reset 0x3 — Configuration register for APB2AVS bridge block
  [31:24] CLK_DIVIDER_DUTY_CYCLE_NUMERATOR — Determines the desired duty cycle of the divided clock (when avs_clock_select is set to select the divided APB clock or refclk clock). This value will be divided by 256 to determine the high-pulse percentage of the divided clock period. Depending on the clk_divider_value, it may not be possible to precisely achieve the desired duty cycle - in that case, the closest possible fit is used. If this is set to 0, a value of 1 will be assumed. Out of reset the divider uses a numerator of 0x80 (50%), not this field's reset value of 0. A write that changes this field or clk_divider_value loads both fields into the divider, so program both together.
  [23:16] CLK_DIVIDER_VALUE — Determines the divisor value used to generate the AVS clock (when avs_clock_select is set to select the divided APB clock or divided refclk clock). The duty cycle of the divided clock depends both on the clk_divider_value together with the clk_divider_duty_cycle_numerator value. A 50% duty cycle is only possible on even clk_divider_values with clk_divider_duty_cycle_numerator set to 128. This field requires a minimum value of 2 - for lower values, 2 will be assumed. Out of reset the divider uses a ratio of 4, not this field's reset value of 0. A write that changes this field or clk_divider_duty_cycle_numerator loads both fields into the divider, so program both together.
  [10] TURN_OFF_ALL_PREMUX_CLOCKS — Gate off all clocks entering the AVS clock mux - do this before changing the mux selection or changing the clock divider settings, then turn back on afterwards
  [9] FORCE_SLAVE_RESYNC_OPERATION — Force master to issue a slave resync (35 AVS clock cycles of holding the mdata signal high) at the next possible opportunity. The request crosses a 3-stage AVS clock synchronizer before the master sees it.
  [8] STOP_AVS_CLOCK_ON_IDLE — When the AVS bus is idle, gate the avs_clock from running. Restart it when there are new commands to be run. The master always issues a slave resync first when the clock restarts.
  [1:0] AVS_CLOCK_SELECT — Selects which clock to use for AVS Clock: [list] [*] 00: Use the APB clock directly as the AVS clock [*] 01: Use a divided version of APB clock as the AVS Clock. The clock divider settings are determined by AVS_CFG_1:clk_divider_value and AVS_CFG_1:clk_divider_duty_cycle_numerator [*] 10: Use the refclk clock directly as the AVS clock [*] 11: Use a divided version of refclk clock as the AVS Clock. The clock divider settings are determined by AVS_CFG_1:clk_divider_value and AVS_CFG_1:clk_divider_duty_cycle_numerator [/list]
0x58 AVS_CONFIG 32-bit reset 0x1 — AVS Configuration Register
  [0] AVS_GPIO_ENABLE — Enable AVSBus connection to GPIOs. The effective sets OE of the GPIOs dedicated to avs_clock and avs_cdata to 1, sets IE of GPIO dedicated to avs_tdata to 1. By default, this is enabled as the AVSBus state machine immediately starts after reset deassertion.

## smc_top.smc_i2c_wrap — Wrapper address map instantiating the per-controller I2C register blocks and shared control.
Base 0xC0005000
{0x0+0x200*i} i2c[{i}] (i=0..2) group — Interrupt status, enable, and test registers for a single I2C controller and target.
  0x00 INTR_STATE 32-bit access per field — Interrupt Status Register
    [19] TARGET_RX_FIFO_ERROR rw write-1-clears — Target Mode interrupt: asserted when the Target RX FIFO has a parity error. Write `1` to clear.
    [18] TARGET_TX_FIFO_ERROR rw write-1-clears — Target Mode interrupt: asserted when the Target TX FIFO has a parity error. Write `1` to clear.
    [17] CONTROLLER_RX_FIFO_ERROR rw write-1-clears — Controller Mode interrupt: asserted when the Controller RX FIFO has a parity error. Write `1` to clear.
    [16] CONTROLLER_TX_FIFO_ERROR rw write-1-clears — Controller Mode interrupt: asserted when the Controller TX FIFO has a parity error. Write `1` to clear.
    [15] SMBALERT rw write-1-clears — Controller Mode interrupt: asserted when `smbalert_ni` is asserted. Write `1` to clear.
    [14] HOST_TIMEOUT rw write-1-clears — Target Mode interrupt: asserted when the controller stops generating the clock longer than `HOST_TIMEOUT_CTRL.VAL`. Write `1` to clear.
    [13] UNEXP_STOP rw write-1-clears — Target Mode interrupt: asserted when the controller sends this target a STOP before this target NACKs. Write `1` to clear.
    [12] ACQ_STRETCH ro — Target Mode interrupt: remains asserted while the target is stretching the clock because 1) the Target RX FIFO is full or 2) the `TARGET_ACK_CTRL.NBYTES` count has reached `0` (only if `CTRL.ACK_CTRL_EN = 1`).
    [11] TX_THRESHOLD ro — Target Mode interrupt: remains asserted while the Target TX FIFO level is less than `TARGET_FIFO_CONFIG.TX_THRESH`.
    [10] TX_STRETCH ro — Target Mode interrupt: remains asserted while this target is stretching the clock or has halted. The flags in the `TARGET_EVENTS` register explain the reason(s) for clock stretching/halting. Clearing the `TARGET_EVENTS` flags clears this interrupt.
    [9] CMD_COMPLETE rw write-1-clears — Controller/Target Mode interrupt: asserted when this/the controller finishes generating a STOP or repeated START. Write `1` to clear.
    [8] SDA_UNSTABLE rw write-1-clears — Controller Mode interrupt: asserted when the target fails to keep SDA stable during a transmission. Write `1` to clear.
    [7] STRETCH_TIMEOUT rw write-1-clears — Controller Mode interrupt: asserted when the target stretches the clock longer than `TIMEOUT_CTRL.VAL` (valid only when `TIMEOUT_CTRL.MODE = 0`). Write `1` to clear.
    [6] SDA_INTERFERENCE rw write-1-clears — Controller Mode interrupt: asserted when SDA is unexpectedly pulled LOW by another controller. Write `1` to clear.
    [5] SCL_INTERFERENCE rw write-1-clears — Controller Mode interrupt: asserted when SCL is unexpectedly pulled LOW by another controller. Write `1` to clear.
    [4] CONTROLLER_HALT ro — Controller Mode interrupt: remains asserted while this controller halts. The flags in the `CONTROLLER_EVENTS` register explain the reason(s) for the halting. Clearing the `CONTROLLER_EVENTS` flags clears this interrupt.
    [3] RX_OVERFLOW rw write-1-clears — Controller Mode interrupt: asserted when the Controller RX FIFO overflows. Write `1` to clear.
    [2] ACQ_THRESHOLD ro — Target Mode interrupt: remains asserted while the Target RX FIFO level is greater than `TARGET_FIFO_CONFIG.ACQ_THRESH`.
    [1] RX_THRESHOLD ro — Controller Mode interrupt: remains asserted while the Controller RX FIFO level is greater than `HOST_FIFO_CONFIG.RX_THRESH`.
    [0] FMT_THRESHOLD ro — Controller Mode interrupt: remains asserted while the Controller TX FIFO level is less than `HOST_FIFO_CONFIG.FMT_THRESH`.
  0x04 INTR_ENABLE 32-bit — Interrupt Enable Register
    [19] TARGET_RX_FIFO_ERROR — Enables the `TARGET_RX_FIFO_ERROR` interrupt.
    [18] TARGET_TX_FIFO_ERROR — Enables the `TARGET_TX_FIFO_ERROR` interrupt.
    [17] CONTROLLER_RX_FIFO_ERROR — Enables the `CONTROLLER_RX_FIFO_ERROR` interrupt.
    [16] CONTROLLER_TX_FIFO_ERROR — Enables the `CONTROLLER_TX_FIFO_ERROR` interrupt.
    [15] SMBALERT — Enables the `SMBALERT` interrupt.
    [14] HOST_TIMEOUT — Enables the `HOST_TIMEOUT` interrupt.
    [13] UNEXP_STOP — Enables the `UNEXP_STOP` interrupt.
    [12] ACQ_STRETCH — Enables the `ACQ_STRETCH` interrupt.
    [11] TX_THRESHOLD — Enables the `TX_THRESHOLD` interrupt.
    [10] TX_STRETCH — Enables the `TX_STRETCH` interrupt.
    [9] CMD_COMPLETE — Enables the `CMD_COMPLETE` interrupt.
    [8] SDA_UNSTABLE — Enables the `SDA_UNSTABLE` interrupt.
    [7] STRETCH_TIMEOUT — Enables the `STRETCH_TIMEOUT` interrupt.
    [6] SDA_INTERFERENCE — Enables the `SDA_INTERFERENCE` interrupt.
    [5] SCL_INTERFERENCE — Enables the `SCL_INTERFERENCE` interrupt.
    [4] CONTROLLER_HALT — Enables the `CONTROLLER_HALT` interrupt.
    [3] RX_OVERFLOW — Enables the `RX_OVERFLOW` interrupt.
    [2] ACQ_THRESHOLD — Enables the `ACQ_THRESHOLD` interrupt.
    [1] RX_THRESHOLD — Enables the `RX_THRESHOLD` interrupt.
    [0] FMT_THRESHOLD — Enables the `FMT_THRESHOLD` interrupt.
  0x08 INTR_TEST 32-bit access per field — Interrupt Test Register
    [19] TARGET_RX_FIFO_ERROR wo — Writing `1` forces the `TARGET_RX_FIFO_ERROR` interrupt.
    [18] TARGET_TX_FIFO_ERROR wo — Writing `1` forces the `TARGET_TX_FIFO_ERROR` interrupt.
    [17] CONTROLLER_RX_FIFO_ERROR wo — Writing `1` forces the `CONTROLLER_RX_FIFO_ERROR` interrupt.
    [16] CONTROLLER_TX_FIFO_ERROR wo — Writing `1` forces the `CONTROLLER_TX_FIFO_ERROR` interrupt.
    [15] SMBALERT wo — Writing `1` forces the `SMBALERT` interrupt.
    [14] HOST_TIMEOUT wo — Writing `1` forces the `HOST_TIMEOUT` interrupt.
    [13] UNEXP_STOP wo — Writing `1` forces the `UNEXP_STOP` interrupt.
    [12] ACQ_STRETCH rw — Writing `1` forces the `ACQ_STRETCH` interrupt. Writing `0` releases it.
    [11] TX_THRESHOLD rw — Writing `1` forces the `TX_THRESHOLD` interrupt. Writing `0` releases it.
    [10] TX_STRETCH rw — Writing `1` forces the `TX_STRETCH` interrupt. Writing a `0` releases it.
    [9] CMD_COMPLETE wo — Writing `1` forces the `CMD_COMPLETE` interrupt.
    [8] SDA_UNSTABLE wo — Writing `1` forces the `SDA_UNSTABLE` interrupt.
    [7] STRETCH_TIMEOUT wo — Writing `1` forces the `STRETCH_TIMEOUT` interrupt.
    [6] SDA_INTERFERENCE wo — Writing `1` forces the `SDA_INTERFERENCE` interrupt.
    [5] SCL_INTERFERENCE wo — Writing `1` forces the `SCL_INTERFERENCE` interrupt.
    [4] CONTROLLER_HALT rw — Writing `1` forces the `CONTROLLER_HALT` interrupt. Writing `0` releases it.
    [3] RX_OVERFLOW wo — Writing `1` forces the `RX_OVERFLOW` interrupt.
    [2] ACQ_THRESHOLD rw — Writing `1` forces the `ACQ_THRESHOLD` interrupt. Writing `0` releases it.
    [1] RX_THRESHOLD rw — Writing `1` forces the `RX_THRESHOLD` interrupt. Writing `0` releases it.
    [0] FMT_THRESHOLD rw — Writing `1` forces the `FMT_THRESHOLD` interrupt. Writing `0` releases it.
  0x0C SMBUS_CTRL 32-bit — SMBus Control Register
    [4] SMBALERT — Target Mode control: asserts the `smbalert_no` output. This bit clears itself when the controller addresses this target.
    [0] SMBSUS — Controller Mode control: asserts the `smbsus_no` output.
  0x10 CTRL 32-bit — Control Register
    [7] ACQ_START_STOP_EN — ACQ FIFO Start/Stop Enable (Target Mode only): * `0` - Start/Stop symbols are NOT written into the ACQ FIFO. The firmware should rely on `TARGET_EVENTS.START_DETECT` and `TARGET_EVENTS.STOP_DETECT` flags to detect Start/Stop events. * `1` - Start/Stop symbols ARE written into the ACQ FIFO (legacy behavior). When a START (or repeated START) is detected, an `ACQ_START` or `ACQ_RESTART` entry is written. When a STOP is detected, an `ACQ_STOP` or `ACQ_NACK_STOP` entry is written.
    [6] TX_STRETCH_CTRL_EN — Target mode control: enables the Software TX Stretch Control Mechanism. If this bit is: * `0` - Automatic TX Stretch: When this target receives a READ address byte, it only stretches the clock if the TX FIFO is empty; otherwise, it pops the FIFO and transmits the data byte. The target never sets the `TARGET_EVENTS` register flags in this mode. * `1` - Software TX Stretch Mode: When this target receives a READ address, it always stretches the clock and sets the `TARGET_EVENTS.TX_PENDING` flag. The software can: 1. confirm the release and transmission of the TX FIFO data by writing a 1 to clear the `TARGET_EVENTS.TX_PENDING` flag; or 2. reset the TX FIFO by writing 1 to `FIFO_CTRL.TXRST` and load in new data via the `TXDATA` register--useful whenthe READ address is targeting a different function of the target. In this mode, the target always sets the `TARGET_EVENTS` register flags.
    [5] MULTI_CONTROLLER_MONITOR_EN — Global control: enables the Bus Monitor. Set this bit to `1` only in a multi-controller environment. If a `0`->`1` transition happens while `ENABLEHOST` and `ENABLETARGET` are both `0`, the Bus Monitor will enable and begin in the 'Bus Busy' state. To transition to a 'Bus Free' state, `HOST_TIMEOUT_CTRL` must be nonzero so the Bus Monitor may count out idle cycles to confirm the freedom to transmit. In addition, the Bus Monitor will track whether the bus is free based on the enabled timeouts and detected STOP symbols. For Multi-Controller Mode, ensure `MULTI_CONTROLLER_MONITOR_EN` becomes `1` no later than `ENABLEHOST` or `ENABLETARGET`. This bit can be set at the same time as either or both of the other two, though. Note that if `MULTI_CONTROLLER_MONITOR_EN` is set after `ENABLEHOST` or `ENABLETARGET`, the Bus Monitor will begin in the 'Bus Free' state instead. This would violate the proper protocol for a controller to join a multi-controller environment. However, if this controller is known to be the first to join, this ordering will enable skipping the idle wait. When `0`, the bus monitor will report that the bus is always free, so the Controller FSM is never blocked from transmitting.
    [4] ACK_CTRL_EN — Target Mode control: enables the Software ACK Control Mechanism. If this bit is: * `0` - This target ACKs a data byte whenever the ACQ FIFO has space. * `1` - This target ACKs the first `TARGET_ACK_CTRL.NBYTES` bytes. If another byte arrives, this target stretches the clock and awaits software intervention (and asserts `STATUS.ACK_CTRL_STRETCH`). The software can 1. accept the new byte(s) by reloading the `TARGET_ACK_CTRL.NBYTES` counter; or 2. reject the new byte(s) by writing `1` to `TARGET_ACK_CTRL.NACK` (useful for SMBus).
    [3] NACK_ADDR_AFTER_TIMEOUT — Target Mode control: NACK address after timeout. If this bit is: * `0` - This target ACKs the address byte even if a Stretch Timeout occurs (useful for SMBus). * `1` - This target NACKs the address byte when a Stretch Timeout occurs.
    [2] LLPBK — Global control: enables line loop-back. In Controller Mode, the internal logic sees the `smbalert_ni` input as deasserted. In Target Mode, this target sends all received SDA data back out, and the internal logic sees received data as all 1's.
    [1] ENABLETARGET — Global control: configures this device's operating mode. * `ENABLEHOST = 1` and `ENABLETARGET = 0` — Controller Mode * `ENABLEHOST = 0` and `ENABLETARGET = 1` — Target Mode * `ENABLEHOST = 1` and `ENABLETARGET = 1` — Hybrid Mode * `ENABLEHOST = 0` and `ENABLETARGET = 0` — Monitor Mode
    [0] ENABLEHOST — Global control: configures this device's operating mode. * `ENABLEHOST = 1` and `ENABLETARGET = 0` — Controller Mode * `ENABLEHOST = 0` and `ENABLETARGET = 1` — Target Mode * `ENABLEHOST = 1` and `ENABLETARGET = 1` — Hybrid Mode * `ENABLEHOST = 0` and `ENABLETARGET = 0` — Monitor Mode
  0x14 STATUS 32-bit ro reset 0x33C
    [10] ACK_CTRL_STRETCH — Target Mode status: indicates that this target is stretching the clock due to the Software ACK Control Mechanism. See `CTRL.ACK_CTRL_EN` for details.
    [9] ACQEMPTY — Target Mode status: Target RX FIFO empty.
    [8] TXEMPTY — Target Mode status: Target TX FIFO empty.
    [7] ACQFULL — Target Mode status: Target RX FIFO full.
    [6] TXFULL — Target Mode status: Target TX FIFO full.
    [5] RXEMPTY — Controller Mode status: Controller RX FIFO empty.
    [4] TARGETIDLE — Target Mode status: Target FSM idle.
    [3] HOSTIDLE — Controller Mode status: Controller FSM idle.
    [2] FMTEMPTY — Controller Mode status: Controller TX FIFO Empty.
    [1] RXFULL — Controller Mode status: Controller RX FIFO Full.
    [0] FMTFULL — Controller Mode status: Controller TX FIFO Full.
  0x18 RDATA 32-bit ro — Controller RX FIFO Access Register (Controller Mode only)
    [7:0] DATA read-modifies — Reading this register pops the Controller RX FIFO.
  0x1C FDATA 32-bit wo — Controller TX FIFO Access Register (Controller Mode only)
    [12] NAKOK — NACK OK. When set, this controller will not care if this byte is NACKed. It will not halt, set the `CONTROLLER_EVENTS.NACK` flag, or assert the `CONTROLLER_HALT` Interrupt. This behavior is useful for protocols like Serial Camera Control Bus (SCCB).
    [11] RCONT — Read continue/stop: * `0` — Read Stop: The controller NACKs the last data byte. Use this if this is the last READ in a sequence. * `1` — Read Continue: The controller ACKs the last data byte. Use this if this is an intermediate READ in a sequence.
    [10] READB — Read/write: * `0` - Issue WRITE transaction * `1` - Issue READ transaction
    [9] STOP — Generate a STOP condition on the bus after sending the byte.
    [8] START — Generate a START condition on the bus before sending the byte.
    [7:0] FBYTE — Writing to this register pushes an entry into the Controller TX FIFO. The meaning of this field depends on the value of the `READB` field: * `READB = 0` - This field is the WRITE data byte. * `READB = 1` - This field specifies the number of bytes to read from the target. Setting this field to 0 reads 256 bytes.
  0x20 FIFO_CTRL 32-bit wo — FIFO Control Register
    [8] TXRST — Target Mode control: writing `1` resets the Target TX FIFO.
    [7] ACQRST — Target Mode control: writing `1` resets the Target RX FIFO.
    [1] FMTRST — Controller Mode control: writing `1` resets the Controller TX FIFO.
    [0] RXRST — Controller Mode control: writing `1` resets the Controller RX FIFO.
  0x24 HOST_FIFO_CONFIG 32-bit — Controller FIFO Configuration Register (Controller Mode only)
    [27:16] FMT_THRESH — The `FMT_THRESH` interrupt remains asserted while the Controller TX FIFO level is less than this setting.
    [11:0] RX_THRESH — The `RX_THRESH` interrupt remains asserted while the Controller RX FIFO level is greater than this setting.
  0x28 TARGET_FIFO_CONFIG 32-bit — Target FIFOs Configuration Register (Target Mode only)
    [27:16] ACQ_THRESH — The `ACQ_THRESH` interrupt remains asserted while the Target RX FIFO level is greater than this setting.
    [11:0] TX_THRESH — The `TX_THRESH` interrupt remains asserted while the Target TX FIFO level is less than this setting.
  0x2C HOST_FIFO_STATUS 32-bit ro reset not defined — Controller FIFOs Status Register (Controller Mode only)
    [27:16] RXLVL — Controller RX FIFO fill level, from 0 to the FIFO depth when full.
    [11:0] FMTLVL — Controller TX FIFO fill level, from 0 to the FIFO depth when full.
  0x30 TARGET_FIFO_STATUS 32-bit ro — Target FIFOs Status Register (Target Mode only)
    [27:16] ACQLVL — Target RX FIFO fill level, from 0 to the FIFO depth when full.
    [11:0] TXLVL — Target TX FIFO fill level, from 0 to the FIFO depth when full.
  0x34 OVRD 32-bit — Override Control Register
    [2] SDAVAL — Global control: SDA override value: * `0` - Pull the SDA line low * `1` - Release the SDA line
    [1] SCLVAL — Global control: SCL override value: * `0` - Pull the SCL line low * `1` - Release the SCL line
    [0] TXOVRDEN — Global control: enables control of the SDA and SCL lines through the `SDA_VAL` and `SCL_VAL` fields, respectively.
  0x38 VAL 32-bit ro — Bus Oversampled Values Register
    [31:16] SDA_RX — Global status: contains the last 16 SDA over-sampled values. LSB is most recent.
    [15:0] SCL_RX — Global status: contains the last 16 SCL over-sampled values. LSB is most recent.
  0x3C TIMING0 32-bit — SCL LOW and HIGH Periods Register
    [28:16] TLOW — Global control: specifies the LOW period of SCL (`t_LOW`) in system clock cycles. Must be `≥ 2`. See Table 11 in the I2C Specification for more details. This field is sized to meet the I2C Standard-mode (100 kHz) minimum `t_LOW = 4.7 μs` requirement, assuming a 1 GHz system clock.
    [12:0] THIGH — Global control: specifies the HIGH period of SCL (`t_HIGH`) in system clock cycles. Must be `≥ 2`. See Table 11 in the I²C Specification for details. This field is sized to meet the I2C Standard-mode (100 kHz)'s minimum `t_HIGH = 4.0 μs` requirement, assuming a 1 GHz system clock.
  0x40 TIMING1 32-bit — Bus Rise and Fall Times Register
    [24:16] T_F — Global control: specifies the fall time of SDA and SCL (`t_f`) in system clock cycles. The fall time is measured from 70% to 30% of the signal swing. See Table 11 in the I2C Specification for more details. This field is sized to meet I2C Standard-mode (100 kHz)'s maximum `t_f = 300 ns` requirement, assuming a 1 GHz system clock.
    [9:0] T_R — Global control: specifies the rise time of SDA and SCL (`t_r`) in system clock cycles. The rise time is measured from 30% to 70% of the signal swing. See Table 11 in the I2C Specification for more details. This field is sized to meet I2C Standard-mode (100 kHz)'s maximum `t_r = 1000 ns` requirement, assuming a 1 GHz system clock.
  0x44 TIMING2 32-bit — START Condition Setup and Hold Times Register
    [28:16] THD_STA — Global control: specifies the setup time for a (repeated) START condition (`t_HD;STA`) in system clock cycles. See Table 11 in the I2C Specification for details. This field is sized to meet I2C Standard-mode (100 kHz)'s minimum `t_HD;STA = 4.0 μs` requirement, assuming a 1 GHz system clock.
    [12:0] TSU_STA — Global control: specifies the setup time for a repeated START condition (`t_SU;STA`) in system clock cycles. See Table 11 in the I2C Specification for details. This field is sized to meet I2C Standard-mode (100 kHz)'s minimum `t_SU;STA = 4.7 μs` requirement, assuming a 1 GHz system clock.
  0x48 TIMING3 32-bit — Data Setup and Hold Times Register
    [28:16] THD_DAT — Global control: specifies the data and (N)ACK bits hold time (`t_HD;DAT`) in system clock cycles. See Table 11 in the I2C Specification for details. This field is sized to meet the I2C Standard-mode (100 kHz)'s `t_HD;DAT = 5.0 μs` minimum requirement, assuming a 1 GHz system clock.
    [8:0] TSU_DAT — Global control: specifies the data setup time (`t_SU;DAT`) in system clock cycles. See Table 11 in the I2C Specification for details. This field is sized to meet the I2C Standard-mode (100 kHz)'s `t_SU;DAT = 250 ns` minimum requirement, assuming a 1 GHz system clock.
  0x4C TIMING4 32-bit — STOP Condition Setup Time and Bus Free Time Register
    [28:16] T_BUF — Global control: specifies the time between a STOP and START condition (`t_BUF`) in system clock cycles. See Table 11 in the I²C Specification for details. This field is sized to meet I2C Standard-mode (100kHz)'s `t_BUF = 4.7 μs` minimum requirement, assuming a 1 GHz system clock.
    [12:0] TSU_STO — Global control: specifies the setup time for a STOP condition (`t_SU;STO`) in system clock cycles. See Table 11 in the I²C Specification for details. This field is sized to meet I2C Standard-mode (100 kHz)'s `t_SU;STO = 4.0 μs` minimum requirement, assuming a 1 GHz system clock.
  0x50 TIMEOUT_CTRL 32-bit — Timeout Control Register
    [31] EN — Timeout Enable.
    [30] MODE — Global control: timeout mode. * `0` - Stretch Timeout (Controller Mode only). If the target stretches the clock for more time than `TIMEOUT_CTRL.VAL`, the `STRETCH_TIMEOUT` interrupt will be asserted. * `1` - Bus Timeout. If SCL is LOW for more time than `TIMEOUT_CTRL.VAL`: * In Controller Mode, the `CONTROLLER_EVENTS.BUS_TIMEOUT` flag will be asserted, triggering the `CONTROLLER_HALT` interrupt. * In Target Mode, the `TARGET_EVENTS.BUS_TIMEOUT` flag will be set, triggering the `TX_STRETCH` interrupt.
    [29:0] VAL — Global control: Specifies the timeout value in system clock cycles. The meaning of this field depends on `MODE`.
  0x54 TARGET_ID 32-bit — Target ID Register (Target Mode only)
    [27:21] MASK1 — ADDRESS1 mask.
    [20:14] ADDRESS1 — Target Address 1. This target responds if the 7-bit address matches `ADDRESS1 & MASK1`. `MASK1 = 0x0` disables this address.
    [13:7] MASK0 — ADDRESS0 mask.
    [6:0] ADDRESS0 — Target Address 0. This target responds if the 7-bit address matches `ADDRESS0 & MASK0`. `MASK0 = 0x0` disables this address.
  0x58 ACQDATA 32-bit ro — Target RX FIFO Access Register (Target Mode only)
    [10:8] SIGNAL — This field indicates if this FIFO entry represents/is associated with control signal(s): * `0x0` - The entry is an ordinary data byte that has been ACKed. * `0x1` - The entry is an address byte preceded by a START. * `0x2` - The entry is a STOP condition following ACKed data bytes. * `0x3` - The entry is an address byte preceded by a repeated START. * `0x4` - The entry is a NACKed data byte. * `0x5` - The entry is an address byte preceded by a (repeated) START. However, the data bytes that followed this address byte were NACKed. * `0x6` - Error. A transaction preceding ended abnormally, for example, due to an unexpected STOP condition, a Bus or Stretch Timeout, a software NACK, or a lost arbitration. If the FIFO does not have enough space to record a complete transaction, an Error (`0x6`) entry may appear alone.
    [7:0] ABYTE read-modifies — Reading this register pops the ACQ FIFO. The meaning of this field depends on `SIGNAL`: * `SIGNAL = 0x0`, `0x1`, `0x3`, `0x4`, or `0x5` - This field contains an address or data byte sent by the controller. * `SIGNAL = 0x2`, `0x6` - This field is meaningless.
  0x5C TXDATA 32-bit wo — Target TX FIFO Access Register (Target Mode only).
    [7:0] DATA — Writing to this register pushes data into the Target TX FIFO. The controller reads data from this FIFO during a READ transaction.
  0x60 HOST_TIMEOUT_CTRL 32-bit — Controller Timeout Control Register
    [30:0] VAL — Target/Monitor Mode control: controller clock generation timeout value specified in system clock cycles. * Target Mode - If the controller stops generating the clock for more time than this setting, this target asserts the Controller Timeout Interrupt. * Monitor Mode - this field is required to be nonzero for the Bus Monitor to transition out of the initial Busy state. Set this field to `0x0` to disable this behavior.
  0x64 TARGET_TIMEOUT_CTRL 32-bit — Target Timeout Control Register (Target Mode only)
    [31] EN — Enable Target Timeout.
    [30:0] VAL — When this target has stretched the clock for more time than this setting, this target will NACK incoming data bytes or release the SDA line for outgoing data bytes. The count is cumulative over an entire transaction. In other words, this is SMBus's cumulative target clock extension time. The behavior for the address byte is configurable via `CTRL.NACK_ADDR_AFTER_TIMEOUT`.
  0x68 TARGET_NACK_COUNT 32-bit — Target NACK Count Register (Target Mode only)
    [7:0] TARGET_NACK_COUNT read-clears — Indicates the number of transactions NACKed by this target since the last read of this register, saturating at 255. This field can be used to track how many transactions were missed when the Target RX FIFO is full.
  0x6C TARGET_ACK_CTRL 32-bit access per field — Target ACK Control Register (Target Mode only)
    [31] NACK wo — When `STATUS.ACK_CTRL_STRETCH = 1`, writing `1` to this field causes this target to NACK all bytes of the transaction. Effective only when `CTRL.ACK_CTRL_EN = 1`.
    [8:0] NBYTES rw — When `STATUS.ACK_CTRL_STRETCH = 1`, writing to this register specifies the number of bytes this target should ACK. The count decrements per byte ACKed. Effective only when `CTRL.ACK_CTRL_EN = 1`. See `CTRL.ACK_CTRL_EN` for details. This control field is used to implement SMBus's mid-transfer (N)ACK responses.
  0x70 ACQ_FIFO_NEXT_DATA 32-bit ro — Target RX FIFO Next Byte Register (Target Mode only)
    [7:0] DATA — This field contains the next byte to be pushed into the Target RX FIFO, allowing software to decide whether to accept or reject it. Valid only when `STATUS.ACK_CTRL_STRETCH = 1`. See `CTRL.ACK_CTRL_EN` for details.
  0x74 HOST_NACK_HANDLER_TIMEOUT 32-bit — Controller NACK Timeout Register (Controller Mode only)
    [31] EN — Enables Controller NACK Timeout.
    [30:0] VAL — Timeout value (specified in system clock cycles) for this controller Mode to automatically STOP a transaction when `CONTROLLER_EVENTS.NACK` is set.
  0x78 CONTROLLER_EVENTS 32-bit — Controller Events Register (Controller Mode only)
    [3] ARBITRATION_LOST write-1-clears — Indicates that the controller has halted due to it losing an arbitration against another controller. This bit triggers the `CONTROLLER_HALT` interrupt. Writing `1` clears this bit.
    [2] BUS_TIMEOUT write-1-clears — Indicates that this controller has halted due to a Bus Timeout. See `TIMEOUT_CTRL` for details. This bit triggers the `CONTROLLER_HALT` interrupt. Writing `1` clears this bit.
    [1] UNHANDLED_NACK_TIMEOUT write-1-clears — Indicates that this controller has halted due to a Controller NACK Timeout. See `HOST_NACK_HANDLER_TIMEOUT` for details. This bit triggers the `CONTROLLER_HALT` interrupt. Writing `1` clears this bit.
    [0] NACK write-1-clears — Indicates that this controller has halted due to an unexpected NACK sent by the target. This behavior can be disabled by writing `1` to `FDATA.NAKOK`. This bit triggers the `CONTROLLER_HALT` interrupt. Writing `1` clears this bit.
  0x7C TARGET_EVENTS 32-bit — Target Events Register (Target Mode)
    [4] STOP_DETECT write-1-clears — Stop Detect Flag (Target Mode only). Set to 1 by hardware when a STOP is detected while `CTRL.ENABLETARGET = 1`. Cleared when software writes 1.
    [3] START_DETECT write-1-clears — Start Detect Flag (Target Mode only). Set to 1 by hardware when a START (or repeated START) is detected while `CTRL.ENABLETARGET = 1`. Cleared when software writes 1.
    [2] ARBITRATION_LOST write-1-clears — Indicates that a controller has lost arbitration, causing a READ transaction to end. This bit triggers the `TX_STRETCH` interrupt. Writing `1` clears this bit.
    [1] BUS_TIMEOUT write-1-clears — Indicates that this target has halted due a Bus Timeout terminating a READ transaction. See `TIMEOUT_CTRL` for details. This bit triggers the `TX_STRETCH` interrupt. Writing `1` clears this bit.
    [0] TX_PENDING write-1-clears — Indicates that the target is stretching the clock due to receiving a READ address byte and waiting for software to confirm the release of the Target TX FIFO data. Valid only if `CTRL.TX_STRETCH_CTRL_EN = 1`. See `CTRL.TX_STRETCH_CTRL_EN` for details. This bit triggers the `TX_STRETCH` interrupt. Writing `1` clears this bit.
  0x80 SMBUS_STATUS 32-bit ro
    [4] SMBALERT — Controller Mode status: indicates that the `smbalert_ni` input is asserted.
    [0] SMBSUS — Target Mode status: indicates that the `smbsus_ni` input is asserted.
0xE00 i2c_ctrl_regs group — Per-instance pad-function select, SMBus pad direction, and SMBus alert enable.
  {0x0+4j} I2C_CTRL[{j}] (j=0..2) 32-bit — Control Register
    [8] SMBUS_EN — SMBus Enable. Gates the SMBus Alert signal.
    [4] I2C_CONTROLLER_MODE_EN — SMBus Pad Direction. When set, the SMBus alert pad is an input and the SMBus suspend pad is an output, as for an SMBus host. When clear, the alert pad is an output and the suspend pad is an input, as for an SMBus target. SCL and SDA are unaffected. Program it to agree with the core's CTRL.ENABLEHOST and CTRL.ENABLETARGET setting.
    [0] I2C_EN — I2C Pad Function Select. When set, the integration routes this instance's SCL, SDA, SMBus alert and SMBus suspend signals to their pads. Does not enable the I2C core; CTRL.ENABLEHOST and CTRL.ENABLETARGET select the core's operating mode.

## smc_top.smc_uart_wrap — Wrapper address map instantiating the per-UART log-engine blocks.
Base 0xC0006000
{0x0+0x400*i} uart_log_engine_wrap[{i}] (i=0..3) group — Composes the UART 16550 core, log engine, and their control registers for one UART instance.
  0x00 uart_log_engine_ctrl group — Top-level enable register for the UART log-engine block.
    0x00 CTRL 32-bit — Control Register
      [0] UART_EN — UART Enable. The hardware LSIO request of the UART's RX, TX, RTS and CTS pads: while set, the UART owns their data and direction. While clear, the UART keeps running, but its pads follow the GPIO data and direction selection like any pad without a hardware request, so TX and RTS do not reach the pins unless software forces LSIO selection.
  0x100 uart group — Contains the mode-independent registers and the read-only registers accessible only when `DLAB = 0`.
    0x00 RBR 32-bit ro — Receiver Buffer Register
      [7:0] DATA read-modifies — Received Data. Contains a received character. If FIFOs are enabled, this field points to the bottom of the RX FIFO. Otherwise, this field points to a single- byte Receiver Buffer Register.
    0x04 IER 32-bit — Interrupt Enable Register
      [4] EFEI — Enable FIFO Error Interrupt.
      [3] EDSSI — Enable (Delta Status of) Modem Status Interrupt.
      [2] ELSI — Enable (Receiver) Line Status Interrupt.
      [1] ETBEI — Enable Transmitter Buffer Empty (Transmitter Holding Register Empty) Interrupt.
      [0] ERBFI — Enable Receiver Buffer Full (Received Data Ready) Interrupt.
    0x08 IIR 32-bit ro reset 0x1 — Interrupt Identification Register
      [7:6] FIFOS_ENABLED — FIFOs Enabled: * `0x0` - FIFOs are disabled * `0x3` - FIFOs are enabled
      [3:1] INTERRUPT_ID — Interrupt ID: * `0x7` - FIFO Error Interrupt (priority 0) * `0x3` - Receiver Line Status Interrupt (priority 1) * `0x6` - Reception Timeout Interrupt (priority 2) * `0x2` - Received Data Ready Interrupt (priority 3) * `0x1` - Transmitter Holding Register Empty Interrupt (priority 4) * `0x0` - Modem Status Interrupt (priority 5)
      [0] INTERRUPT_PENDING — Interrupt Pending. Active-low.
    0x0C LCR 32-bit — Line Control Register
      [7] DLAB — Divisor Latch Access Bit. If set, allows access to the `DLL` and `DLM` registers when accessing addresses `0x0` and `0x4`, respectively. If unset, allows access to the `THR`, `RBR`, and `IER` registers. `IIR` and `FCR` are accessible regardless of this bit.
      [6] SET_BREAK — Set Break. If set, forces the `tx_o` output to `0` to cause a break condition on the receiving UART.
      [5] STICK_PARITY — Stick Parity. If set, forces the transmit and received parity bits to be `0` if even parity is selected and `1` if odd parity is selected.
      [4] EPS — Even Parity Select: * `1` - even parity * `0` - odd parity
      [3] PEN — Parity Enable.
      [2] STB — Stop Bits: * `0` - 1 stop bit. * `1` - 2 stop bits. The transmitter always sends 2 stop bits; with 5-bit words the receiver checks only the first.
      [1:0] WLS — Word Length Select: * `0x0` - 5 bits per character * `0x1` - 6 bits per character * `0x2` - 7 bits per character * `0x3` - 8 bits per character
    0x10 MCR 32-bit — Modem Control Register
      [5] LINE_LOOPBACK — Line Loopback. If set, the `rx_i` input is internally connected to the `tx_o` output.
      [4] LOOP — System Loopback. If set, the transmitter is internally connected to the receiver. The `tx_o` output is set to `1`.
      [3] OUT2 — User Output 2. Writing to this bit drives the `out2_no` in the opposite polarity.
      [2] OUT1 — User Output 1. Writing to this bit drives the `out1_no` in the opposite polarity.
      [1] RTS — Request to Send. Writing to this bit drives the `rts_no` output in the opposite polarity.
      [0] DTR — Data Terminal Ready. Writing to this bit drives the `dtr_no` output in the opposite polarity.
    0x14 LSR 32-bit ro reset 0x60 — Line Status Register
      [7] ERROR_IN_RCVR_FIFO — Error in Receiver FIFO. When set, indicates that the receiver FIFO or (RBR in non-FIFO mode) has the parity, framing, or break error. In other words, at least one of the PE, FE, and BI bits is set.
      [6] TEMT — Transmitter Empty. When set, indicates that the transmitter shift register and the transmitter FIFO (or THR in non-FIFO mode) are empty.
      [5] THRE — Transmitter Holding Register Empty. When set, indicates that the TX FIFO (or THR in non-FIFO mode) is empty. Clearing the Transmitter Holding Register Empty Interrupt does NOT clear this bit.
      [4] BI read-clears — Break Interrupt. When set, indicates that the `rx_i` input is `0` for an entire frame's time (start + data + parity + stop bits). In FIFO mode, this bit set when the character reaches the top of the receiver FIFO. In non-FIFO mode, this bit is set when the character enters the RBR. This bit triggers the Receiver Line Status Interrupt.
      [3] FE read-clears — Framing Error. When set, indicates that the received character is missing a stop bit. In FIFO mode, this bit is set when the character reaches the top of the FIFO. In non-FIFO mode, this bit is set when the character enters the RBR. This bit triggers the Receiver Line Status Interrupt.
      [2] PE read-clears — Parity Error. When set, indicates that the character at the top of the receiver FIFO (or RBR in non-FIFO mode) has a parity error. This bit triggers the Receiver Line Status Interrupt.
      [1] OE read-clears — Overrun Error. When set, indicates that the RX FIFO was full when a new character was received; the new character is dropped. This bit sets only in FIFO mode: in non-FIFO mode a new character overwrites an unread character in the RBR without setting it. This bit triggers the Receiver Line Status Interrupt.
      [0] DR — Data Ready. When set, indicates that the RX FIFO (or RBR in non-FIFO mode) contains data.
    0x18 MSR 32-bit ro — Modem Status Register
      [7] DCD — Data Carrier Detect. This bit reflects the `dcd_ni` input in the opposite polarity, so it reads `1` while a carrier is detected.
      [6] RI — Ring Indicator. This bit reflects the `ri_ni` input in the opposite polarity, so it reads `1` while the remote modem signals an incoming call.
      [5] DSR — Data Set Ready. This bit reflects the `dsr_ni` input in the opposite polarity, so it reads `1` while the remote modem is connected and ready.
      [4] CTS — Clear to Send. This bit reflects the `cts_ni` input in the opposite polarity, so it reads `1` while the remote device is ready to receive data.
      [3] DDCD read-clears — Delta Data Carrier Detect. When set, indicates that the `DCD` bit has changed since the last time this register was read. This bit triggers the Modem Status Interrupt.
      [2] TERI read-clears — Trailing Edge Ring Indicator. When set, indicates that the `RI` bit has changed from a `1` to a `0`. This bit triggers the Modem Status Interrupt.
      [1] DDSR read-clears — Delta Data Set Ready. When set, indicates that the `DSR` bit has changed since the last time this register was read. This bit triggers the Modem Status Interrupt.
      [0] DCTS read-clears — Delta Clear to Send. When set, indicates that the `CTS` bit has changed since the last time this register was read. This bit triggers the Modem Status Interrupt.
    0x1C SCR 32-bit — Scratch Register
      [7:0] SCR — Scratch. Holds user data.
    0x20 ECR 32-bit — Extended Control Register
      [1:0] RCVR_TRIGGER_MS2B — Receiver FIFO Trigger Level Most Significant 2 Bits. To configure the least significant 2 bits, use the `FCR.RCVR_TRIGGER` register field. The configurations for the trigger levels are: * `0x0` - 1 character * `0x1` - 4 characters * `0x2` - 8 characters * `0x3` - 14 characters * `0x4` - 32 characters * `0x5` - 64 characters * `0x6` - 128 characters * `0x7` - 256 characters * `0x8` - 512 characters * `0x9` - 1024 characters * `0xA` - 2048 characters * `0xB` - 4096 characters The Received Data Ready interrupt asserts while the receive FIFO holds at least the selected number of characters. A level above the receive FIFO depth, and any combined value above `0xB`, never asserts it.
    0x24 ITR 32-bit — Interrupt Test Register
      [5] TRTI — Test Reception Timeout Interrupt. Writing a `1` forces the interrupt and writing `0` releases it.
      [4] TFEI — Test FIFO Error Interrupt. Writing `1` forces the interrupt and writing `0` releases it.
      [3] TDSSI — Test (Delta Status of) Modem Status Interrupt. Writing `1` forces the interrupt and writing `0` releases it.
      [2] TLSI — Test (Receiver) Line Status Interrupt. Writing `1` forces the interrupt and writing `0` releases it.
      [1] TTBEI — Test Transmitter Buffer Empty (Transmitter Holding Register Empty) Interrupt. Writing `1` forces the interrupt and writing `0` releases it.
      [0] TRBFI — Test Receiver Buffer Full (Received Data Ready) Interrupt. Writing `1` forces the interrupt and writing `0` releases it.
  0x200 log_engine group — Configuration and status registers for the UART log engine, including the log region and write pointers.
    0x00 CTRL 32-bit — Control Register
      [0] EN — Log Engine Enable. When set, enables the Log Engine. When cleared, the engine stops fetching and writing, discards buffered log data and resets transfer progress. Configuration and pending LOG_LEN values are retained, so a pending entry restarts from the start of its slot when the engine is enabled again. Clearing does not wait for outstanding bus responses.
    0x04 LOG_REGION_SIZE 32-bit
      [19:0] LOG_REGION_SIZE — Log region size in bytes. Supported values are at most 512 KiB and aligned to 128 bytes (16 slots times the 8-byte fetch beat). If software programs a larger value, RTL clamps the effective region to 512 KiB. For a value that is not 128-byte aligned, RTL divides the effective region among the 16 slots and rounds each slot's transferable capacity down to complete 8-byte fetch beats. A requested LOG_LEN above that capacity is clamped to the capacity.
    0x08 LOG_REGION_ADDR access per field — Log Region Address Register
      [55:32] LOG_REGION_ADDR_HI rw — Log Region Start Address High. Contains fabric address bits [55:32].
      [31:0] LOG_REGION_ADDR_LO rw — Log Region Start Address Low.
    0x10 LOG_WRITE_ADDR 32-bit — Log Write Address Register
      [31:0] LOG_WRITE_ADDR — Log Write Address. This is the address where the log data is written to.
    0x14 INTR_STATUS 32-bit — Interrupt Status Register
      [4] LOG_WRITE_ERR write-1-clears — Log Write Error Interrupt. Asserted when the bus for writing log data returns an error.
      [0] LOG_FETCH_ERR write-1-clears — Log Fetch Error Interrupt. Asserted when the bus for fetching log data returns an error.
    0x18 INTR_ENABLE 32-bit — Interrupt Enable Register
      [4] LOG_WRITE_ERR — Log Write Error Interrupt Enable.
      [0] LOG_FETCH_ERR — Log Fetch Error Interrupt Enable.
    0x1C INTR_TEST 32-bit wo — Interrupt Test Register
      [4] LOG_WRITE_ERR — Log Write Error Interrupt Test. Writing `1` forces the interrupt.
      [0] LOG_FETCH_ERR — Log Fetch Error Interrupt Test. Writing `1` forces the interrupt.
    {0x40+4k} LOG_CTRL[{k}] (k=0..15) 32-bit — Log Control Register
      [15:0] LOG_LEN — Log Length. Writing a nonzero value representing the log length in bytes to this field starts the log transfer process. The field holds the requested length until the transfer completes, when hardware clears it to zero; it is not a remaining-byte counter. There are 16 copies of this register, each representing a log entry. The log entries go through round robin arbitration.

## smc_top.smc_efuse_map — Address map for efuse shadow registers providing access to various chip configuration and ID fields
Base 0xC0007000
0x00 HARNESS_LOCKS — Lock controls for each fuse field. When write locked, the corresponding field is not programmable. When read locked, the shadow register is not readable.
  [15] spare_tail_read_lock write-1-sets — Spare tail read lock (slot 7). When set, no SPARE_TAIL element is readable.
  [14] spare_tail_write_lock write-1-sets — Spare tail write lock (slot 7). When set, no SPARE_TAIL element is writable.
  [13] spare2_read_lock write-1-sets — Spare 2 read lock (slot 6). When set, SPARE[2] is not readable.
  [12] spare2_write_lock write-1-sets — Spare 2 write lock (slot 6). When set, SPARE[2] is not writable.
  [11] spare1_read_lock write-1-sets — Spare 1 read lock (slot 5). When set, SPARE[1] is not readable.
  [10] spare1_write_lock write-1-sets — Spare 1 write lock (slot 5). When set, SPARE[1] is not writable.
  [9] spare0_read_lock write-1-sets — Spare 0 read lock (slot 4). When set, SPARE[0] is not readable.
  [8] spare0_write_lock write-1-sets — Spare 0 write lock (slot 4). When set, SPARE[0] is not writable.
  [7] occp_transport_timeout_read_lock write-1-sets — OCCP transport timeout read lock (slot 3). When set, OCCP_TRANSPORT_TIMEOUT is not readable.
  [6] occp_transport_timeout_write_lock write-1-sets — OCCP transport timeout write lock (slot 3). When set, OCCP_TRANSPORT_TIMEOUT is not writable.
  [5] smc_config_read_lock write-1-sets — SMC config read lock (slot 2). When set, SMC_CONFIG is not readable.
  [4] smc_config_write_lock write-1-sets — SMC config write lock (slot 2). When set, SMC_CONFIG is not writable.
  [3] i2c_i3c_id_read_lock write-1-sets — I2C/I3C ID read lock (slot 1). When set, no I2C_I3C_ID element is readable.
  [2] i2c_i3c_id_write_lock write-1-sets — I2C/I3C ID write lock (slot 1). When set, no I2C_I3C_ID element is writable.
  [1] jtag_public_identity_read_lock write-1-sets — JTAG public identity read lock (slot 0). When set, JTAG_PUBLIC_IDENTITY is not readable.
  [0] jtag_public_identity_write_lock write-1-sets — JTAG public identity write lock (slot 0). When set, JTAG_PUBLIC_IDENTITY is not writable.
0x08 SUPPLEMENTARY_LOCKS — Lock controls for the supplementary fuse region. When write locked, the corresponding supplementary lock region is not programmable. When read locked, its shadow register is not readable.
  [2n+1] region{n}_read_lock write-1-sets (n=0..31) — Supplementary region {n} read lock. When set, supplementary lock region {n} is not readable.
  [2n] region{n}_write_lock write-1-sets (n=0..31) — Supplementary region {n} write lock. When set, supplementary lock region {n} is not writable.
0x10 JTAG_PUBLIC_IDENTITY 256-bit — JTAG-public exception window. In PROD and RMA_SiP, JTAG reads of this range are admitted while JTAG access to every other fuse field is blocked. Encoding is adopter-defined; the harness does not interpret or consume the value. The slot-0 read lock still hides the bits when set.
  [255:0] value — Opaque payload. Encoding is adopter-defined; the harness does not interpret it.
{0x30+8i} I2C_I3C_ID[{i}] (i=0..8) — I2C/I3C interface ID
  [63:0] interface_id — I2C or I3C ID configuration: * Static ID mode: [6:0] contains ID, [63:7] reserved * Provisional ID mode: [63:0] full ID
0x78 SMC_CONFIG — SMC boot and configuration controls sourced from fuse. Only the low word carries assigned bits, so firmware reads it as a single 32-bit access.
  [63:16] config_rsvd_high — Reserved for future configuration bits.
  [15] dft_ignore_error — When set, boot continues despite a reported memory repair or MBIST failure.
  [14:8] config_rsvd_mid — Reserved for future configuration bits.
  [7] sram_auto_zero_disable — When set, boot skips the SRAM auto-zero initialisation pass.
  [6:1] config_rsvd_low — Reserved for future configuration bits.
  [0] rom_flip_endianness — When set, the ROM interface swaps byte order on instruction fetch.
0x80 OCCP_TRANSPORT_TIMEOUT — OCCP transport timeout in the low word; upper word reserved.
  [63:32] timeout_rsvd — Reserved for extension of the timeout encoding.
  [31:0] timeout — Transport timeout value consumed by the boot ROM OCCP driver.
{0x88+0x20*i} SPARE[{i}] (i=0..2) 256-bit — Individually lockable 256-bit spare region, reserved for fields assigned after the RTL is frozen. Each element has its own write/read lock pair in HARNESS_LOCKS.
  [255:0] rsvd — Spare fuse bits for future use.
{0xE8+8i} SPARE_TAIL[{i}] (i=0..2) — 64-bit spare region at the end of the map, reserved for fields assigned after the RTL is frozen. All elements share the slot-7 write/read lock pair in HARNESS_LOCKS.
  [63:0] rsvd — Spare fuse bits for future use.

## smc_top.efuse_interface_ctrl — Program and read command, address, data, status, and timeout registers for the eFuse interface.
Base 0xC0008000
0x00 EFUSE_INTERFACE_CTRL_STATUS 32-bit access per field (reset mask 0x770) — eFuse interface status and error-clear register. Reports the sense-done flag and request/address error conditions, and provides write-1 strobes to clear those errors.
  [10] efuse_read_addr_error_clear wo — Clears the read out of bounds error bit (efuse_read_addr_error) in efuse_ctrl_status
  [9] efuse_program_addr_error_clear wo — Clears the program out of bounds error bit (efuse_program_addr_error) in efuse_ctrl_status
  [8] efuse_req_error_clear wo — Clears the blocked request error bit in efuse_ctrl_status
  [6] efuse_read_addr_error ro — Indicates that an invalid eFuse read address was used (address exceeds the implemented eFuse size). The error must be cleared by writing 1 to efuse_read_addr_error_clear.
  [5] efuse_program_addr_error ro — Indicates that an invalid eFuse program address was used (address exceeds the implemented eFuse size). The error must be cleared by writing 1 to efuse_program_addr_error_clear.
  [4] efuse_req_error ro — Indicates that the eFuse was blocked because of either read or a program lock. The error must be cleared by writing 1 to efuse_req_error_clear to this register
  [0] efuse_sense_done ro — Indicates if the eFuse state machine has completed
0x04 EFUSE_PROGRAM_CTRL 32-bit access per field — eFuse program control and status. Configures the program data, triggers a program of the bit at EFUSE_PROGRAM_ADDR (optionally with read-back), and reports program progress and completion status.
  [27] program_enable rw — When set, enables the program request
  [26] program_status ro — 0: No Error. 1: Error
  [25] program_done ro — When set, the program has completed, the status of which is in program_status
  [24] program_busy ro — When set, the program is in progress
  [18] efuse_program_read_back rw — When set, trigger a read back after a program
  [17] efuse_program_go rw — When set, triggers a program to the eFuse. This will be ignored if the lock bit is set
  [16] efuse_data rw — Data to program to eFuse. If this bit is 0, the program request will be ignored
0x08 EFUSE_READ_CTRL 32-bit access per field — eFuse read control and status. Triggers a read of the word at EFUSE_READ_ADDR and reports read progress and completion status.
  [28] read_enable rw — When set, enables the read request
  [26] read_status ro — 0: No Error. 1: Error. Set when read_go is asserted while read is not enabled, the address is out of bounds, or the read request times out.
  [25] read_done ro — When set, the read has completed, the status of which is in read_status
  [24] read_busy ro — When set, the read is in progress
  [16] efuse_read_go rw — When set, triggers a read to efuse.
0x0C EFUSE_PROGRAM_INTERFACE_READ_DATA 32-bit ro — Read data captured through the program interface. Hardware debug only; valid only while the program interface state machine is in its capture-data state.
  [31:0] dout — Read Data from eFuse through program interface. This field is only valid when the efuse programming interface is utilized to burn the efuse IP and only when the state machine is during ST_CAPTUER_DATA state. Hardware debug only
0x10 EFUSE_READ_INTERFACE_READ_DATA 32-bit ro — Read data returned through the eFuse read interface.
  [31:0] dout — Read Data from eFuse through READ interface.
0x14 EFUSE_READ_REQ_TIMEOUT 32-bit reset 0x800000 — Read interface timeout configuration. Sets the number of cycles the read interface waits for a SHIM response and enables the read timeout.
  [28] read_req_timout_enable — Enable timeout on read interface
  [27:0] read_req_timeout_cycles — Number of cycles the read interface will wait for a response from the shim. At 100MHz this can count ~= 2.5 seconds.
0x18 EFUSE_PROGRAM_REQ_TIMEOUT 32-bit reset 0x800000 — Program interface timeout configuration. Sets the number of cycles the program interface waits for a SHIM response and enables the program timeout.
  [28] program_req_timeout_enable — Enable timeout on program interface.
  [27:0] program_req_timeout_cycles — Number of cycles the program interface will wait for a response from the shim. At 100MHz this can count ~= 2.5 seconds.
0x1C EFUSE_PROGRAM_ADDR 32-bit — Bit address for the next program. Set it before EFUSE_PROGRAM_CTRL.efuse_program_go.
  [31:0] efuse_addr — Bit address to program. Writing this register does not check the address; a program started with an address at or beyond the implemented eFuse size is not issued and sets efuse_program_addr_error.
0x20 EFUSE_READ_ADDR 32-bit — Bit address for the next read. Set it before EFUSE_READ_CTRL.efuse_read_go.
  [31:0] efuse_addr — Bit address of the word to read. Writing this register does not check the address; a read started with an address at or beyond the implemented eFuse size is not issued and sets efuse_read_addr_error.

## smc_top.smc_telemetry_receiver_wrap — Wrapper address map instantiating the telemetry receiver channels.
Base 0xC0009000
{0x0+0x100*i} telemetry_receiver[{i}] (i=0..2) group — Configuration, status, and data-buffer registers for a single telemetry receiver channel.
  0x00 CTRL 32-bit access per field — Control Register
    [23:12] BUFFER_THRESHOLD rw — Telemetry Message Buffer Threshold. The Telemetry Buffer Threshold Interrupt is asserted when the number of entries in the buffer is greater than this value. Only the low log2(queue depth)+1 bits are compared, so values alias modulo twice the queue depth, and only values below the queue depth can assert the interrupt.
    [8] TELEMETRY_TX_FLUSH rw — Telemetry Transmitter Flush. Writing `1` flushes all FIFOs in the telemetry transmitter. The flushing is done via the ATB AF interface. This bit clears itself when the transmitter acknowledges the flush. Writing `0` while a flush is pending withdraws the request, so other fields of this register must be updated with a read-modify-write while the bit is set.
    [4] TELEMETRY_RX_FLUSH wo — Telemetry Receiver Flush. Writing `1` discards queued messages and resets the assembly write pointer. Stored payload bytes are not cleared. In particular, a later short message can retain trailing counter values and validity from an earlier message. This operation does not erase storage.
    [0] BUFFER_POP wo — Telemetry Message Buffer Pop. Effective only if `STATUS.BUFFER_EMPTY = 0`. Writing `1` pops the buffer and thus updates the data in the `TELEMETRY_PROBE_ID`, `TELEMETRY_COUNTER_VLDS`, and `TELEMETRY_COUNTER[32]` registers.
  0x04 STATUS 32-bit ro reset 0x1
    [4] BUFFER_FULL — Telemetry Message Buffer Full.
    [0] BUFFER_EMPTY — Telemetry Message Buffer Empty.
  0x08 INTR_STATUS 32-bit access per field — Interrupt Status Register
    [4] BUFFER_THRESHOLD ro — Telemetry Message Buffer Threshold Interrupt. Asserted when the number of telemetry messages in the Telemetry Message Buffer is greater than `CTRL.BUFFER_THRESHOLD`.
    [0] MISSING_LAST rw write-1-clears — Last Packet Missing Interrupt. Asserted when the Telemetry Receiver has not received a Last Packet flag when the maximum number of packets a message can consist of has been received.
  0x0C INTR_ENABLE 32-bit — Interrupt Enable Register
    [4] BUFFER_THRESHOLD — Telemetry Message Buffer Threshold Interrupt Enable.
    [0] MISSING_LAST — Last Packet Missing Interrupt Enable.
  0x10 INTR_TEST 32-bit access per field — Interrupt Test Register
    [4] BUFFER_THRESHOLD rw — Telemetry Message Buffer Threshold Interrupt Test. Writing `1` forces the interrupt and writing `0` releases it.
    [0] MISSING_LAST wo — Last Packet Missing Interrupt Test. Writing `1` forces the interrupt.
  0x14 TELEMETRY_PROBE_ID 32-bit ro
    [4:0] PROBE_ID — Probe ID. Contains the Probe ID field of the telemetry message at the bottom of the Telemetry Message Buffer.
  0x18 TELEMETRY_COUNTER_VLDS 32-bit ro — Telemetry Counter Valid Bits Register
    [31:0] COUNTER_VLDS — Counter Valid Bits. Indicates which of the counter values in the telemetry message at the bottom of the Telemetry Message Buffer are valid. Bit `i` is for the `i`-th counter.
  {0x80+4j} TELEMETRY_COUNTER[{j}] (j=0..31) 32-bit ro
    [31:0] COUNTER — Counter Value. Contains one of the 32 counter values in the telemetry message at the bottom of the Telemetry Message Buffer.

## smc_top.smc_system_timer_octs — Open Chiplet Time Synchronization (OCTS) System Timer Registers
Base 0xC000A000
0x00 TIMER_START 32-bit — System Timer Start Register
  [0] START — Start the system timer. In PRIMARY mode, a write of 1 loads the preset and pulses the sync-load output for PULSE_WIDTH cycles. In SECONDARY mode, the write has no effect; a secondary starts on the primary's sync-load pulse, which is what loads its preset. Ensure both primary and secondary are out of reset.
0x04 CTRL 32-bit reset 0x1020A — System Timer Control Register
  [23:16] STEP — Step amount for secondary timer
  [15:8] PULSE_WIDTH — Pulse width for sync load and credit signals. A value of 0 will be rounded up to 1. WARNING: This value must be less than CREDIT_VAL
  [7:0] CREDIT_VAL — Credit value factor. WARNING: This value must be greater than PULSE_WIDTH
0x08 STATUS 32-bit ro — System Timer Status Register
  [4] RUNNING — Timer is enabled and its count is nonzero.
  [0] MODE — Timer mode driven by the is_primary_i input: 0=PRIMARY (is_primary_i=1), 1=SECONDARY (is_primary_i=0).
0x0C TIMER_PRESET_LO 32-bit — System Timer Preset Value [31:0]
  [31:0] PRESET_LO — Lower 32 bits of preset value
0x10 TIMER_PRESET_HI 32-bit — System Timer Preset Value [63:32]
  [31:0] PRESET_HI — Upper 32 bits of preset value
0x14 TIMER_COUNT_LO 32-bit ro — Current System Timer Count [31:0]
  [31:0] COUNT_LO — Lower 32 bits of current timer count
0x18 TIMER_COUNT_HI 32-bit ro — Current System Timer Count [63:32]
  [31:0] COUNT_HI — Upper 32 bits of current timer count
0x1C CREDIT_EXPIRED 32-bit
  [31:0] MAX_CYCLES_EXPIRED — Maximum number of clock cycles since a count credit expired (SECONDARY only). To reset the value of this register, write anything to it. If this number is very high (exact value depends on clock speed and credit value), this indicates that the secondary has not received a count credit pulse in a while, and is likely not syncing properly with the primary. This register can also be used to determine the clock skew between the primary and secondary. If PRIMARY, this field is always 0.
0x20 TIMER_GPIO_ENABLE 32-bit — System Timer GPIO Enable Register
  [0] GPIO_ENABLE — Enable the GPIO pad lsio interface for the system timer. This is done to prevent X-prop on reset into the secondary timer, which can cause the secondary timer to start counting early.

## smc_top.dtp_ctrl_reg — External Memory
Base 0xC000B000
{0x0+4i} mem_array[{i}] (i=0..511) 32-bit reset not defined
  [31:0] data

## smc_top.dfx_ctrl — Memory-repair and MBIST status, debug clock and cross-trigger controls, and debug-mux selects.
Base 0xC000B800
0x00 STATUS_SMU ro
  [12] mbist_abort — One bit indicator from DFT logic to say that MBIST has hit timeout and aborted This register is sticky 1 and will hold the value until reset
  [8] mbist_pass — One bit indicator from DFT logic to say when MBIST is successful This register is sticky 1 and will hold the value until reset
  [4] mbist_done — One bit indicator from DFT logic to say when MBIST is completed This register is sticky 1 and will hold the value until reset
  [2] mem_repair_abort — One bit indicator from DFT logic to say that mem repair has hit timeout and aborted This register is sticky 1 and will hold the value until reset
  [1] mem_repair_success — One bit indicator from DFT logic to say if mem repair was successful This register is sticky 1 and will hold the value until reset
  [0] mem_repair_done — One bit indicator from DFT logic to say when mem repair is completed. This register is sticky 1 and will hold the value until reset
0x08 DEBUG_CTRL 32-bit
  [30:23] debug_marker — Holds the written value for software to read back. It has no effect in the SMC; the debug marker on the SMC debug bus comes from the core logic analyzer (CLA).
  [22:7] xtrig_clk_halt_mask — CLA cross-trigger and halt-clock enable. Bit 0 (register bit 7) enables every CLA cross-trigger output lane together with the CLA halt-clock request; 0 holds them all inactive. Bits 15:1 hold the written value for software to read back and have no effect.
  [6] dtb_ew_en — Holds the written value for software to read back. It has no effect in the SMC.
  [5] dtb_ns_en — Holds the written value for software to read back. It has no effect in the SMC.
  [4] force_clk_en — Design-for-debug (DFD) clock force. 1 keeps the DFD clock running whatever the value of cg_en.
  [3] cg_en — DFD clock stop. 1 stops the clock to the debug-bus muxes and the CLA unless force_clk_en is 1; 0 lets it run. The clock also runs while the SMC is in reset. While the clock is stopped, CLA and DST register accesses complete with an error and reads return 0xBADCAB1E.
  [2] gpio_en — Holds the written value for software to read back. It has no effect in the SMC.
  [1:0] chiplet_enable — Holds the written value for software to read back. It has no effect in the SMC.
0x10 DEBUG_BUS_MUX — Mode, ID and lane selects for the twelve debug-bus muxes that reduce the SMC debug bus to the 16 CLA input lanes. Each mux takes its mode while Dbmid equals its ID, and its lane selects while Dbmid equals its ID and its mode is 1, so program one mux at a time.
  [6n+21:6n+16] Muxselseg{n} (n=4..7) — No effect in the SMC: each debug-bus mux has four output lanes, selected by Muxselseg0 to Muxselseg3.
  [6n+21:6n+16] Muxselseg{n} (n=0..3) — Binary input-lane select for output lane {n} of the addressed debug-bus mux, which takes eight 16-bit input lanes and drives four. 0 selects input lane {n}; a value k from 1 to 4 selects input lane k+3, so 4 selects lane 7; 5 to 63 drive zero.
  [15:8] Rsvd158 — No effect in the SMC: the field stores and reads back, but no debug-bus mux uses it. Write 0.
  [7:2] Dbmid — ID of the debug-bus mux to program: 3 to 6 address the level-2 muxes and 7 to 14 the level-3 muxes.
  [1:0] Dbmmode — Mode selection, 0: DBM off, 1: Normal debug mode, 2: DBM ID output mode, 3: Toggle Mode

## smc_top.smc_pwm — Wrapper address map instantiating the PWM register block and its pad control.
Base 0xC000C000
0x00 pwm group — Transmission of pulse-width modulated output signals with adjustable duty cycle
  0x00 ALERT_TEST 32-bit wo
    [0] fatal_fault — Write 1 to trigger one alert event of this kind.
  0x04 REGWEN 32-bit reset 0x1
    [0] REGWEN write-0-clears — When true, all writable registers can be modified. When false, they become read-only. Defaults true, write zero to clear. This can be cleared after initial configuration at boot in order to lock in the supplied register settings.
  0x08 CFG 32-bit reset 0x38008000
    [31] CNTR_EN — Assert this bit to enable the PWM phase counter. Clearing this bit disables and resets the phase counter.
    [30:27] DC_RESN — Phase Resolution (logarithmic). All duty-cycle and phase shift registers represent fractional PWM cycles, expressed in units of 2^-16 PWM cycles. Each PWM cycle is divided into 2^(DC_RESN+1) time slices, and thus only the (DC_RESN+1) most significant bits of each phase or duty cycle register are relevant.
    [26:0] CLK_DIV — Sets the period of each PWM beat to be (CLK_DIV+1) input clock periods. Since PWM pulses are generated once every 2^(DC_RESN+1) beats, the period between output pulses is 2^(DC_RESN+1)*(CLK_DIV+1) times longer than the input clock period.
  0x0C PWM_EN 32-bit
    [3:0] EN — Write 1 to this bit to enable PWM pulses on the corresponding channel.
  0x10 INVERT 32-bit
    [3:0] INVERT — Write 1 to this bit to invert the output for each channel, so that the corresponding output is active-low.
  {0x14+4j} PWM_PARAM[{j}] (j=0..3) 32-bit
    [31] BLINK_EN — Enables blink (or heartbeat). If cleared, the output duty cycle will remain constant at DUTY_CYCLE.A. Enabling this bit causes the PWM duty cycle to alternate between DUTY_CYCLE.A and DUTY_CYCLE.B
    [30] HTBT_EN — Modulates blink behavior to create a heartbeat effect. When HTBT_EN is set, the duty cycle increases (or decreases) linearly from DUTY_CYCLE.A to DUTY_CYCLE.B and back, in steps of (BLINK_PARAM.Y+1), with an increment (decrement) once every (BLINK_PARAM.X+1) PWM cycles. When HTBT_EN is cleared, the standard blink behavior applies, meaning that the output duty cycle alternates between DUTY_CYCLE.A for (BLINK_PARAM.X+1) pulses and DUTY_CYCLE.B for (BLINK_PARAM.Y+1) pulses.
    [15:0] PHASE_DELAY — Phase delay of the PWM leading edge, in units of 2^(-16) PWM cycles. The leading edge will be the rising edge of the output signal unless the corresponding INVERT bit is set.
  {0x24+4j} DUTY_CYCLE[{j}] (j=0..3) 32-bit reset 0x7FFF7FFF
    [31:16] B — The target duty cycle for PWM output, in units of 2^(-16)ths of a pulse cycle. The actual precision is however limited to the (DC_RESN+1) most significant bits. This setting only applies when blinking, and determines the target duty cycle.
    [15:0] A — The initial duty cycle for PWM output, in units of 2^(-16)ths of a pulse cycle. The actual precision is however limited to the (DC_RESN+1) most significant bits. This setting applies continuously when not blinking and determines the initial duty cycle when blinking.
  {0x34+4j} BLINK_PARAM[{j}] (j=0..3) 32-bit
    [31:16] Y — This blink-rate timing parameter has two different interpretations depending on whether or not the heartbeat feature is enabled. If heartbeat is disabled, a blinking PWM will pulse at duty cycle B for (Y+1) pulse cycles before returning to duty cycle A. If heartbeat is enabled the duty cycle will increase (or decrease) by (Y+1) units every time it is incremented (or decremented).
    [15:0] X — This blink-rate timing parameter has two different interpretations depending on whether or not the heartbeat feature is enabled. If heartbeat is disabled, a blinking PWM will pulse at duty cycle A for (X+1) pulse cycles before switching to duty cycle B. If heartbeat is enabled the duty cycle will start at duty cycle A, but will be incremented (or decremented) every (X+1) cycles. In heartbeat mode is enabled, the size of each step is controlled by BLINK_PARAM.Y.
0x800 pwm_ctrl group — Per-channel pad-function select for the PWM outputs.
  0x00 CTRL 32-bit — Control Register
    [3:0] PAD_EN — PWM Pad Function Select, one bit per channel. When bit i is set, the integration routes channel i's output to its pad. Does not start the channel; PWM_EN starts and stops each channel's waveform.

## smc_top.smc_base_config — Base-address, region-size, per-block clock-gating enable, and interrupt configuration registers.
Base 0xC0010000
0x00 GLOBAL_BASE reset 0x40000000
  [55:0] base — Global base address for the CPU
0x08 LOCAL_BASE ro reset 0xC0000000
  [55:0] base — Local base address for the CPU
0x10 REGION_SIZE reset 0x1000000
  [31:0] size — Region size for SMC resources, sizing both the local alias window and the global aperture. Must be a non-zero power of two: the fabric derives its local-alias address mask as (size - 1), so any other value produces a discontiguous mask and misroutes accesses. Zero leaves no reachable local aperture. GLOBAL_BASE and LOCAL_BASE must be aligned to this size. An inbound access at or above BASE + this size answers DECERR; a unit that extends past the limit stays reachable below it. Pick a size that no unit straddles. Defaults to 16MB (0x100_0000); FW reprograms per chiplet spec.
0x18 CLOCK_GATE_CONTROL reset 0x1F000000
  [29:24] cg_hysteresis — Clockgate cg_hysteresis
  [13] telemetry_cg_en — Clock gate enable for telemetry. While set, the telemetry receiver clocks are stopped and every access to the SMC_TELEMETRY_RECEIVER_WRAP window answers SLVERR with read data 0xBADCAB1E.
  [12] uart_cg_en — Clock gate enable for UART. While set, the UART peripheral clock is stopped and every access to the SMC_UART_WRAP window answers SLVERR with read data 0xBADCAB1E.
  [11] i2c_cg_en — Clock gate enable for I2C. While set, the I2C peripheral clock is stopped and every access to the SMC_I2C_WRAP window answers SLVERR with read data 0xBADCAB1E.
  [10] avs_cg_en — Clock gate enable for AVSBus. While set, the AVSBus controller clocks are stopped and every access to the SMC_AVSBUS_CONTROLLER window answers SLVERR with read data 0xBADCAB1E.
  [9] i3c_cg_en — Clock gate enable for I3C. While set, the I3C peripheral clock is stopped and every access to the OCA_I3C_WRAP window answers SLVERR with read data 0xBADCAB1E.
  [8] zeroer_cg_en — Clock gate enable for axi zeroer
  [7] output_fabric_cg_en — Clock gate enable for the output fabric remap demux and mux
  [6] addr_remap_cg_en — Clock gate enable for address remapper register logic
  [5] filter_ib_reg_cg_en — Clockgate enable for inbound filter registers
  [4] filter_ib_axi_cg_en — Clockgate enable for the inbound filters
  [3] filter_ob_reg_cg_en — Clockgate enable for outbound filter registers
  [2] filter_ob_axi_cg_en — Clockgate enable for the outbound filters
  [1] mailbox_cg_en — Clockgate enable for the mailbox
  [0] dma_cg_en — Clockgate enable for the DMA
0x20 HANG_DET_SYS_AXI_CTRL 32-bit access per field — AXI hang detector control and interrupt status.
  [12] irq ro — Reads 1 while this detector's interrupt is asserted, from a timeout or from irq_test, and 0 while enable or irq_en is clear. A live level, not a latch: it clears when the interrupt drops. Writes are ignored.
  [8] irq_test rw — Interrupt test. When 1, asserts irq_o without a bus stall, so firmware can exercise the interrupt path. Gated by enable and irq_en: it substitutes for the timeout, it does not override the interrupt enable.
  [4] irq_en rw — Interrupt enable. When irq_en and enable are high, irq_o follows the detector; when 0, irq_o is held low. Gates a real timeout and irq_test alike.
  [0] enable rw — When 1, the timeout counter runs. When 0, the counter reloads from the threshold and irq_o is forced low.
0x28 HANG_DET_SYS_AXI_TIMEOUT_THRESHOLD 32-bit reset 0x1000 — Consecutive cycles with outstanding AXI transactions and no completion before a timeout fires. The timeout rises on the next cycle and holds until the stall ends.
  [19:0] value — Threshold in clock cycles. Default 0x1000. 20 bits => up to ~1M cycles (~1ms at 1GHz). A timeout fires only if the threshold loaded when the stall count last restarted is non-zero, so 0 disables timeout detection: a stalled bus never times out, though irq_test still asserts irq_o. A threshold write takes effect when the stall count next restarts (on a completion, an idle bus, or enable cleared). So it does not change a stall already being timed.
0x30 HANG_DET_SEP_AXI_CTRL 32-bit access per field — AXI hang detector control and interrupt status.
  fields as HANG_DET_SYS_AXI_CTRL
0x38 HANG_DET_SEP_AXI_TIMEOUT_THRESHOLD 32-bit reset 0x1000 — Consecutive cycles with outstanding AXI transactions and no completion before a timeout fires. The timeout rises on the next cycle and holds until the stall ends.
  fields as HANG_DET_SYS_AXI_TIMEOUT_THRESHOLD
0x40 HANG_DET_DATA_ACCEL_CTRL 32-bit access per field — AXI hang detector control and interrupt status.
  fields as HANG_DET_SYS_AXI_CTRL
0x48 HANG_DET_DATA_ACCEL_TIMEOUT_THRESHOLD 32-bit reset 0x1000 — Consecutive cycles with outstanding AXI transactions and no completion before a timeout fires. The timeout rises on the next cycle and holds until the stall ends.
  fields as HANG_DET_SYS_AXI_TIMEOUT_THRESHOLD

## smc_top.smc_alias_remap_wrap — Wrapper address map instantiating one alias remap register block per remap region.
Base 0xC0012000
{0x0+0x20*i} alias_remap[{i}] (i=0..7) group — TLB Registers for address remapping and attribute tagging
  0x00 REGION group
    0x00 region_start
      [55:12] start_addr — Start of remap region
    0x08 region_end
      [55:12] end_addr — End of remap region (non-inclusive). A region whose end is at or below its start contains no address and never remaps.
    0x10 region_attrs
      [63] valid — If set, this remap will be active
      [59:56] cacheable — Set to change the value of the axcache field of the transaction. This field will override all existing axcache bits.
      [55:12] offset — The value of this field is added to bits [55:12] of the input address when it falls within the remap region. The addition is modulo 2^44, so a carry out of bit 55 is discarded. The lower 12 bits of the address are preserved unchanged. When more than one valid region contains the address, the lowest-numbered region applies.

## smc_top.smc_mmode_remap_wrap — Wrapper address map instantiating one output remap register block per remap region.
Base 0xC0013000
Same registers: smc_top.smc_xvisor_remap_wrap 0xC0014000
{0x0+8i} output_remap[{i}] (i=0..7) group — Address-translation registers that remap outbound transactions and tag their attributes.
  0x00 REGION group
    0x00 region_attrs
      [63] valid — If set, accesses to this region are remapped by offset; if clear, they pass through with their address unchanged
      [55:0] offset — Address translation for remap region. RTL will use the number of bits appropriate for region granulaity. e.g. SMC: 8 * 1MB regions --> 20 bits of address space per region, 36 MSBs from this register used SEP: 16 * 512KB regions --> 19 bits of address space per region, 37 MSBs from this register used

## smc_top.smc_inbound_filter_ctrl_wrap — Wrapper address map instantiating one filter control register block per filter entry.
Base 0xC0015000
Same registers: smc_top.smc_outbound_filter_ctrl_wrap 0xC0016000
{0x0+0x20*i} filter_ctrl[{i}] (i=0..15) group — Per-filter access-control registers defining permitted address ranges and transaction attributes.
  0x00 FILTER_CONFIG access per field reset 0x3000
    [63] locked rw write-1-sets — Lock filter configurations. Write once register. Once set, this bit cannot be cleared, and every subsequent write to this filter entry's FILTER_CONFIG, START_ADDR and END_ADDR registers is steered to the AXI error subordinate and terminates with a DECERR response; reads still return the locked configuration.
    [24] allow_burst rw — Filter entry will match if this field is 1 or if this field is 0 and the burst len AxLEN is 0. This field also selects the granule of the address range: 4KB when it is 1, 2^data_bus_width bytes when it is 0. See start_addr and end_addr for how the range is widened to that granule.
    [23:20] group_id rw — Group ID field to match. Filter entry will match if the transactions group_id matches the value in this field. Note the corner case is the opposite of src_id: the bypass keys off the transaction, not this field. A transaction whose group_id is 0 matches regardless of this field, and a value of 0 here is not a wildcard. Unused for SEP/SMC, where group_id filtering is disabled at build time and this field has no effect
    [19:16] src_id rw — Source ID field to match. Filter entry will match if the transactions src_id matches the value in this field. A value of 0 in this field is a wildcard: src_id matching is bypassed and the entry matches any src_id. Consequently there is no way to match only transactions whose src_id is 0.
    [14:12] data_bus_width ro — Data bus width in bytes, encoded as 2^value: log2 of the instance's AXI data width in bytes, 3 for a 64-bit bus. The register has no storage, and the reset value is the 64-bit case.
    [8] allow_ns rw — Secure and Non-secure is categorized as AxPROT[1] in the AXI protocol, where AxPROT[1] == 0 means secure and AxPROT[1] == 1 means Non-secure. Filter entry will match if AxPROT[1] matches the value in this field
    [4] entry_enabled rw — Filter entry enabled. A = 0 means this entry is disabled, A = 1 means this entry is enabled and will be used to filter
    [1] write_allowed rw — Upon match of transaction to filter fields, whether the transaction has write permissions
    [0] read_allowed rw — Upon match of transaction to filter fields, whether the transaction has read permissions
  0x08 START_ADDR
    [55:0] start_addr — Start of the allowable address range, rounded down to the base of its granule. The granule is 4KB when allow_burst is 1, and 2^data_bus_width bytes when allow_burst is 0. Address matching ignores the address bits below the granule, so the accepted range always spans whole granules and is never narrower than one: a range shorter than the granule, start_addr == end_addr included, still admits the whole granule, and two granules if it straddles a granule boundary. Hardware writes the rounded start_addr and end_addr back into these fields only when both land in the same granule; otherwise readback returns the programmed values even though matching is still granule-aligned.
  0x10 END_ADDR reset 0x7
    [55:0] end_addr — End of the allowable address range, rounded up to the top of its granule. The granule and the write-back behaviour are described under start_addr. Resets to 7, the top of the first 8-byte granule that applies while bursts are disabled on a 64-bit bus; the reset does not follow the data width.

## smc_top.smc_mailbox — SMC-side wrapper instantiating the AXI-Lite mailbox pairs. Each outbound_mailbox_N / inbound_mailbox_N pair is the two apertures of one bidirectional mailbox and shares a single pair of FIFOs: data written through WRITE_DATA in one aperture is what READ_DATA in the other aperture returns. The outbound/inbound naming reflects intended use, not an access restriction.
Base 0xC0018000
{0x0+0x1000*i} outbound_mailbox_{i} group (i=0..31) — Register interface for a single AXI-Lite mailbox: data FIFOs, level and status flags, and interrupt controls.
  0x00 WRITE_DATA wo
    [63:0] write_data — Write data to mailbox fifo. Any write pushes one entry, irrespective of WSTRB, including a write with no byte lanes enabled; byte lanes whose strobe is 0 are pushed as 0.
  0x08 READ_DATA ro reset not defined — A read of any size or alignment within this register pops one whole 64-bit entry from the mailbox fifo, and only the byte lanes it requests are returned. A 32-bit read of either half therefore discards the other half of the entry; read this register with 64-bit accesses. A read while the fifo is empty returns 0x0000_0000_FEED_DEAD with an error response.
    [63:0] read_data read-modifies — Read data from mailbox fifo
  0x10 STATUS ro reset 0x1
    [3] read_level_above_thresh — If set, read fifo level is higher than threshold set in RIRQT
    [2] write_level_above_thresh — If set, write fifo level is higher than threshold set in WIRQT
    [1] full — 0: Space is available to write, 1: Space is not available to write
    [0] empty — 0: Data is available to read, 1: Data is not available to read
  0x18 ERROR_FLAGS ro — A read of any size or alignment within this register clears every flag in it. The flags are only returned in the lower 32 bits, so a 32-bit read of the upper half returns 0 and still clears them; read this register with 64-bit accesses or at its lower half.
    [1] write_error read-clears — Attempted write to a full mailbox
    [0] read_error read-clears — Attempted read from an empty mailbox
  0x20 WIRQT
    [63:0] wirqt — When the usage pointer of the FIFO connected to the W channel exceeds this value, a write threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the write FIFO is full.
  0x28 RIRQT
    [63:0] rirqt — When the fill pointer of the FIFO connected to the R channel exceeds this value, a read threshold IRQ is triggered and the corresponding STATUS register bit is set. When a value larger than or equal to the MailboxDepth parameter is written to this register, it gets reduced to MailboxDepth - 1 to ensure an IRQ is triggered when the read FIFO is full.
  0x30 IRQS — This register is used to read and clear interrupt requests, regardless of IRQEN register and whether the interrupt is enabled or disabled.
    [2] eirq write-1-clears — On read: [0]: No interrupt request [1]: Error on mailbox access On write: [0]: No acknowledge [1]: Acknowledge and clear interrupt request
    [1] rtirq write-1-clears — On read: [0]: No interrupt request [1]: Usage level threshold in read mailbox exceeded On write: [0]: No acknowledge [1]: Acknowledge and clear interrupt request
    [0] wtirq write-1-clears — On read: [0]: No interrupt request [1]: Usage level threshold in write mailbox exceeded On write: [0]: No acknowledge [1]: Acknowledge and clear interrupt request
  0x38 IRQEN — This register is used to enable and disable which interrupts are sent to the CPU.
    [2] eirq — [0]: Error IRQ disabled [1]: Error IRQ enabled
    [1] rtirq — [0]: Read threshold IRQ disabled [1]: Read threshold IRQ enabled
    [0] wtirq — [0]: Write threshold IRQ disabled [1]: Write threshold IRQ enabled
  0x40 IRQP ro — This register is used to read the current status of the interrupts sent to the CPU.
    [2] eirq — [0]: No error IRQ pending [1]: Error IRQ pending
    [1] rtirq — [0]: No read threshold IRQ pending [1]: Read threshold IRQ pending
    [0] wtirq — [0]: No write threshold IRQ pending [1]: Write threshold IRQ pending
  0x48 CTRL wo
    [1] rflush — Flush the read FIFO for this port. The FIFO empties at the end of the cycle in which this write is accepted; a word the peer pushes in that cycle is discarded.
    [0] wflush — Flush the write FIFO for this port. The FIFO empties at the end of the cycle in which this write is accepted.
{0x800+0x1000*i} inbound_mailbox_{i} group (i=0..31) — Register interface for a single AXI-Lite mailbox: data FIFOs, level and status flags, and interrupt controls.
  0x00 WRITE_DATA wo
    fields as outbound_mailbox_0.WRITE_DATA
  0x08 READ_DATA ro reset not defined — A read of any size or alignment within this register pops one whole 64-bit entry from the mailbox fifo, and only the byte lanes it requests are returned. A 32-bit read of either half therefore discards the other half of the entry; read this register with 64-bit accesses. A read while the fifo is empty returns 0x0000_0000_FEED_DEAD with an error response.
    [63:0] read_data read-modifies — Read data from mailbox fifo
  0x10 STATUS ro reset 0x1
    fields as outbound_mailbox_0.STATUS
  0x18 ERROR_FLAGS ro — A read of any size or alignment within this register clears every flag in it. The flags are only returned in the lower 32 bits, so a 32-bit read of the upper half returns 0 and still clears them; read this register with 64-bit accesses or at its lower half.
    fields as outbound_mailbox_0.ERROR_FLAGS
  0x20 WIRQT
    fields as outbound_mailbox_0.WIRQT
  0x28 RIRQT
    fields as outbound_mailbox_0.RIRQT
  0x30 IRQS — This register is used to read and clear interrupt requests, regardless of IRQEN register and whether the interrupt is enabled or disabled.
    fields as outbound_mailbox_0.IRQS
  0x38 IRQEN — This register is used to enable and disable which interrupts are sent to the CPU.
    fields as outbound_mailbox_0.IRQEN
  0x40 IRQP ro — This register is used to read the current status of the interrupts sent to the CPU.
    fields as outbound_mailbox_0.IRQP
  0x48 CTRL wo
    fields as outbound_mailbox_0.CTRL

## smc_top.dma_ctrl — Source, destination, length, and control registers for the iDMA data-mover engine.
Base 0xC0038000
0x00 CONFIG 32-bit
  [10] ENABLED_ND — Repetition enable. 1: the copy is performed NUM_REPETITIONS times, with SRC_STRIDE and DST_STRIDE added to the addresses between rows, modulo 2^56 and without an error when a row address wraps; set it for every transfer, including a linear copy with NUM_REPETITIONS = 1. 0: the repetition count is forced to zero, so the command completes with an error response, moves no data, and still retires its transfer ID.
  [9:7] DST_MAX_LLEN — Base-2 logarithm of the maximum write burst length in 64-bit beats, applied when DST_REDUCE_LEN is 1. A write burst does not cross a boundary aligned to 2^(DST_MAX_LLEN+3) bytes; 0 gives single-beat bursts. Ignored when DST_REDUCE_LEN is 0.
  [6:4] SRC_MAX_LLEN — Base-2 logarithm of the maximum read burst length in 64-bit beats, applied when SRC_REDUCE_LEN is 1. A read burst does not cross a boundary aligned to 2^(SRC_MAX_LLEN+3) bytes; 0 gives single-beat bursts. Ignored when SRC_REDUCE_LEN is 0.
  [3] DST_REDUCE_LEN — Destination burst-length reduction. 1: write bursts are limited by DST_MAX_LLEN. 0: a write burst is at most 256 beats and does not cross a 2 KiB-aligned boundary.
  [2] SRC_REDUCE_LEN — Source burst-length reduction. 1: read bursts are limited by SRC_MAX_LLEN. 0: a read burst is at most 256 beats and does not cross a 2 KiB-aligned boundary.
  [1] DECOUPLE_RW — Read/write decoupling. 0: read and write bursts are formed in lockstep, one write burst per read burst. 1: read and write bursts are formed and issued independently; this mode can deadlock.
  [0] DECOUPLE_AW — Write-address decoupling. 0: the write address of each burst is held until the first data beat of that burst is ready to be written. 1: write addresses are issued without waiting for write data.
{0x4+4i} STATUS_{i} 32-bit ro (i=0..15)
  [9:0] BUSY — Status for the active stream: bits [7:0] each indicate readiness to accept another command, bit 8 reads 1 while a submitted command is queued or still being expanded into rows and falls when the backend accepts the last row of the last queued command, and bit 9 is zero. These bits do not report backend busy or prove transfer completion; use DONE for completed transfer IDs. Unused streams read zero.
{0x48+8i} NEXT_ID_{i} 32-bit ro (i=0..15)
  [31:0] DATA — Reading this register starts the DMA transfer and returns its transfer ID. IDs start at 2, advance by one per command and never read 0; 0xFFFFFFFF reads as 1 from the cycle after it is reached. The descriptor is not validated: a command with zero repetitions, including one with CONFIG.ENABLED_ND clear, or with a length of 0 still retires without copying any data. A stream bank that is not implemented starts no transfer and returns 0.
{0xC8+4i} DONE_{i} 32-bit ro (i=0..15)
  [31:0] DATA — Retirement counter for the stream. Resets to 1 and adds 1 per retirement, never reads 0, and reads 1 from the cycle after it reaches 0xFFFFFFFF. A command retires once, except that a command with CONFIG.ENABLED_ND set, a LENGTH of 0 and NUM_REPETITIONS N of 1 or more retires N times. The value therefore equals the ID NEXT_ID returned for the last retired command only while every earlier command retired once. Unused streams read zero.
0x108 DST_ADDRESS_LO 32-bit
  [31:0] DATA — Destination address for DMA to write to, lower 32 bits
0x10C DST_ADDRESS_HI 32-bit
  [31:0] DATA — Destination address for DMA to write to, upper 32 bits. Bits [31:24] (combined address bits [63:56]) are discarded, not checked; program them as zero.
0x110 SRC_ADDRESS_LO 32-bit
  [31:0] DATA — Source address for DMA to read from, lower 32 bits.
0x114 SRC_ADDRESS_HI 32-bit
  [31:0] DATA — Source address for DMA to read from, upper 32 bits. Bits [31:24] (combined address bits [63:56]) are discarded, not checked; program them as zero.
0x118 LENGTH_LO 32-bit
  [31:0] DATA — Number of bytes to move, lower 32 bits.
0x11C LENGTH_HI 32-bit
  [31:0] DATA — Number of bytes to move, upper 32 bits. Bits [31:24] (combined length bits [63:56]) are discarded, not checked; program them as zero.
0x120 DST_STRIDE_LO 32-bit
  [31:0] DATA — Stride amount on destination address side, lower 32 bits
0x124 DST_STRIDE_HI 32-bit
  [31:0] DATA — Stride amount on destination address side, upper 32 bits. Bits [31:24] (combined stride bits [63:56]) are discarded, not checked; program them as zero.
0x128 SRC_STRIDE_LO 32-bit
  [31:0] DATA — Stride amount on source address side, lower 32 bits
0x12C SRC_STRIDE_HI 32-bit
  [31:0] DATA — Stride amount on source address side, upper 32 bits. Bits [31:24] (combined stride bits [63:56]) are discarded, not checked; program them as zero.
0x130 NUM_REPETITIONS_LO 32-bit
  [31:0] DATA — Number of rows to copy, including the first, lower 32 bits. SRC_STRIDE and DST_STRIDE are added to the addresses between rows. Takes effect only when CONFIG.ENABLED_ND is 1.
0x134 NUM_REPETITIONS_HI 32-bit
  [31:0] DATA — Number of rows to copy, upper 32 bits. The DMA uses only the low 32 bits of the row count, so this register is discarded, not checked; program it as zero.

## smc_top.zeroer_ctrl — Control and status registers for the AXI memory-zeroing engine.
Base 0xC0038200
0x00 DEST_ADDR
  [63:0] DEST_ADDR — Byte address to write zeros to. Bits at and above the master address width, 56 in the SMC, are ignored: a clear starts at the address truncated to that width. Program them as zero; the zeroer truncates an out-of-range value rather than rejecting it.
0x08 SIZE
  [63:0] SIZE — Size in bytes of zeros to write
0x10 CTRL_STATUS access per field — Any write to this register triggers the start of the zeroer, irrespective of WSTRB, including a write with no byte lanes enabled. The start is ignored while SIZE is 0. DEST_ADDR and SIZE are captured when a clear starts; later writes to them do not affect the clear in progress. While a clear is still issuing write bursts, a write to this register completes on the bus but does not start a clear. Once the last burst of a clear has been issued, a write starts a new clear even while write responses of the previous clear are outstanding; STATUS then reads 1 across both clears, and the completion interrupt pulses once, when STATUS returns to 0. Wait for STATUS to read 0 before writing this register again.
  [32] STATUS ro — Indicates whether the zeroer is busy. 1 means the zeroer is active, has pending work, or is in an error state; 0 means it is idle with no pending or outstanding work, including after completion.
  [0] INT_EN rw — If enabled, an interrupt will be outputted once zeroer completes.

## smc_top.smc_cpu_ctrl — Per-core reset control and status, reset timing, chip configuration, mailbox, and boot-ROM stub registers for the SMC CPU cluster.
Base 0xC0039000
{0x0+8i} RESET_VECTOR[{i}] (i=0..3) reset 0xC0040000
  [55:0] vector — Boot address of core n, one register per core. Core n starts fetching here when its reset releases, so a write takes effect at that core's next reset release; bit 0 is ignored. While the warm reset is asserted every core takes 0xC004_0000 instead. The register is on the primary reset and keeps its value across a warm reset.
0x20 RESET_CTRL reset 0x10F
  [24] debug_reset_n_n0_scan — Debug Module Reset, active low
  [8] uncore_reset_n_n0_scan — Cluster Uncore Reset, active low. Resets the uncore portion of the chipyard cluster and holds every core in reset with it. The reset waits for the cluster boundary to drain, bounded by RESET_TIMEOUT. WARNING: using this can cause any outstanding axi requests to and from the cluster to cause timeouts/exceptions.
  [n+4] core{n}_reset_pulse_start_n0_scan (n=0..3) — Writing a 1 starts a core reset pulse on core {n}, timed by CORE_RESET_PULSE_COUNT. The bit is not stored and reads 0. Writing a 1 while the pulse runs reloads the count of its current phase, the pre-reset wait or the hold; it does not queue a second pulse. A 0 in core{n}_reset_n_n0_scan holds the core in reset for the whole pulse.
  [n] core{n}_reset_n_n0_scan (n=0..3) — Reset control for the CPU, active low.
0x28 CORE_RESET_PULSE_COUNT access per field reset 0xF00100008
  [35:32] core_resets_done ro — One bit per core, low while that core's reset pulse runs (pre-reset wait and hold), high otherwise. A level reset held through the core's RESET_CTRL reset_n field, or through RESET_CTRL.uncore_reset_n_n0_scan, does not clear it.
  [31:16] post_reset_count rw — Cycles (clk_smc), minus one, that a core reset pulse holds the core in reset.
  [15:0] pre_reset_count rw — Cycles (clk_smc), minus one, from the start of a core reset pulse to reset assertion.
0x30 RESET_TIMEOUT access per field
  [36] reset_timeout ro — Status for the active software uncore reset request: high after the request exceeds timeout_value and remains high until the request is deasserted. Set in both modes.
  [32] reset_applied ro — Live status: high while a requested software uncore reset is applied at the cluster, either after drain completes or after a force-mode timeout. Core resets are not reported.
  [16] timeout_mode rw — Timeout mode: 0 = report the timeout and keep withholding the uncore reset until the drain completes, then apply it; 1 = force the uncore reset on timeout.
  [15:0] timeout_value rw — Cycles (clk_smc) a software uncore reset may stay pending (withheld, waiting for drain) before timeout. 0 = disabled, wait indefinitely. Core resets do not wait.
0x40 REFERENCE_COUNTER
  [63:0] rc — Reference counter for the CPU. Write once, then poll this register until the readback reflects the written value before writing again. The counter keeps advancing, so the readback is at or just above the written value rather than equal to it.
0x50 WDT_TIMEOUT 32-bit reset 0x4000
  [31:0] data — Number of cycles after a core's 1st stage watchdog timeout at which the 2nd stage watchdog timeout occurs. A value of 0 raises the 2nd stage timeout as soon as the 1st stage timeout occurs. Defaults to 16384 cycles
0x58 WDT_TIMEOUT_RESET 32-bit
  [n] reset_cycle_count_{n} (n=0..3) — Reset current cycle count value in 2nd stage watchdog timer
0x60 TEST_CTRL ro
  [31:0] data — Reads 0 in hardware. A simulation testbench can deposit a value here to hand test control values to firmware.
{0x80+8i} SCRATCH[{i}] (i=0..15)
  [31:0] data — Scratch register for the CPU
{0x100+8i} WB_PC_CORE0[{i}] (i=0..7) ro
  [57:0] pc — Writeback PC value
{0x140+8i} WB_PC_CORE1[{i}] (i=0..7) ro
  [57:0] pc — Writeback PC value
{0x180+8i} WB_PC_CORE2[{i}] (i=0..7) ro
  [57:0] pc — Writeback PC value
{0x1C0+8i} WB_PC_CORE3[{i}] (i=0..7) ro
  [57:0] pc — Writeback PC value
0x200 SMC_ATTRIBUTES ro reset not defined
  [45:40] num_mailboxes
  [39:36] mailbox_depth
  [35:33] num_cores
  [32] no_output_remap
  [31:26] sram_size — Total SRAM size is 2 ^ value bytes
  [25:17] num_cpu_interrupts
  [16:8] num_ext_interrupts
  [0] chiplet_is_primary — Indicates if this chiplet is primary (1) or secondary (0). Driven by strap.
{0x240+8i} MUTEX[{i}] (i=0..3) reset 0x1 — A read of any size or alignment within this register attempts to acquire the mutex, but the result is only returned in bit 0. A read that does not include byte 0, such as a 32-bit read of the upper half or a byte read at a non-zero offset, returns 0 even when it acquires the mutex, leaving it held with no owner until it is released. Read this register with an access that includes byte 0.
  [0] mutex — HW mutex. Reads will attempt to acquire mutex, 1 on success. If the mutex is already acquired, the read will return 0. To release the mutex, write any value to the register.
{0x260+8i} SEMA[{i}] (i=0..3)
  [15:0] sema — 16-bit semaphore value to inc/dec. Writing to this register will inc/dec the semaphore value. The written value is treated as a signed number using 2s compliment.
0x280 DUMMY_ROM_0 reset 0x145051300000517
  [63:0] dummy_rom_word_0 — Word 0 of a park loop for a core whose RESET_VECTOR points at DUMMY_ROM_0: the loop points mtvec at its own wfi, masks interrupts and waits. The words are writable by design with no lock, so software may replace the loop; a master that can write them can also write RESET_VECTOR and RESET_CTRL.
0x288 DUMMY_ROM_1 reset 0xFFF0069330551073
  [63:0] dummy_rom_word_1 — Word 1 of a park loop for a core whose RESET_VECTOR points at DUMMY_ROM_0: the loop points mtvec at its own wfi, masks interrupts and waits. The words are writable by design with no lock, so software may replace the loop; a master that can write them can also write RESET_VECTOR and RESET_CTRL.
0x290 DUMMY_ROM_2 reset 0x105000733046B073
  [63:0] dummy_rom_word_2 — Word 2 of a park loop for a core whose RESET_VECTOR points at DUMMY_ROM_0: the loop points mtvec at its own wfi, masks interrupts and waits. The words are writable by design with no lock, so software may replace the loop; a master that can write them can also write RESET_VECTOR and RESET_CTRL.
0x298 DUMMY_ROM_3 reset 0xFFDFF06F
  [63:0] dummy_rom_word_3 — Word 3 of a park loop for a core whose RESET_VECTOR points at DUMMY_ROM_0: the loop points mtvec at its own wfi, masks interrupts and waits. The words are writable by design with no lock, so software may replace the loop; a master that can write them can also write RESET_VECTOR and RESET_CTRL.
{0x2A0+8i} DUMMY_ROM_NULL[{i}] (i=0..3)
  [63:0] dummy_rom_null — Zero padding that fills the 64-byte cache line holding the park loop, so a line fetch of the loop reads no undefined data.

## smc_top.oca_i3c_wrap — Wrapper address map instantiating the per-controller I3C CSR blocks.
Base 0xC003A000
{0x0+0x1000*i} i3c_csr[{i}] (i=0..5) group
  0x00 I3CBase group
    0x00 HCI_VERSION 32-bit ro reset 0x120 — Identifies the implemented MIPI I3C HCI version.
    0x04 HC_CONTROL 32-bit access per field reset 0x40 — Controls host-controller bus operation, mode selection, transaction abort, and Hot-Join handling.
      [31] BUS_ENABLE rw — Host Controller Bus Enable
      [30] RESUME rw write-1-clears — Host Controller Resume: 0 - Controller is running 1 - Controller is suspended Write 1 to resume Controller operations.
      [29] ABORT rw — Host Controller Abort when set to 1
      [12] HALT_ON_CMD_SEQ_TIMEOUT rw — Halt on Command Sequence Timeout when set to 1
      [8] HOT_JOIN_CTRL rw — Hot-Join ACK/NACK Control: 0 - ACK Hot-Join request 1 - NACK Hot-Join request and send Broadcast CCC to disable Hot-Join
      [7] I2C_DEV_PRESENT rw — I2C Device Present on Bus: 0 - pure I3C bus 1 - legacy I2C devices on the bus
      [6] MODE_SELECTOR ro — DMA/PIO Mode Selector: 0 - DMA 1 - PIO
      [4] DATA_BYTE_ORDER_MODE ro — Data Byte Ordering Mode: 0 - Little Endian 1 - Big Endian
      [3] AUTOCMD_DATA_RPT ro — Auto-Command Data Report: 0 - coalesced reporting 1 - separated reporting
      [0] IBA_INCLUDE rw — Include I3C Broadcast Address: 0 - skips I3C Broadcast Address for private transfers 1 - includes I3C Broadcast Address for private transfers
    0x08 CONTROLLER_DEVICE_ADDR 32-bit — Configures the controller dynamic address and indicates whether that address is valid.
      [31] DYNAMIC_ADDR_VALID — Dynamic Address is Valid: 0 - dynamic address is invalid 1 - dynamic address is valid
      [22:16] DYNAMIC_ADDR — Device Dynamic Address
    0x0C HC_CAPABILITIES 32-bit ro reset 0x400 — Reports the host-controller capabilities implemented by this instance.
      [30] SG_CAPABILITY_DC_EN — Device context memory: 0 - must be physically continuous 1 - controller supports scatter-gather
      [29] SG_CAPABILITY_IBI_EN — DMA only: IBI status and IBI Data rings memory: 0 - must be physically continuous 1 - controller supports scatter-gather
      [28] SG_CAPABILITY_CR_EN — DMA only: Command and Response rings memory: 0 - must be physically continuous 1 - controller supports scatter-gather
      [21:20] CMD_SIZE — Size and structure of the Command Descriptor: 2'b0: 2 DWORDs, all other reserved.
      [13] SCHEDULED_COMMANDS_EN — Controller command scheduling: 0 - not supported 1 - supported
      [12] IBI_CREDIT_COUNT_EN — Controller IBI credit count: 0 - not supported 1 - supported
      [11] IBI_DATA_ABORT_EN — Controller IBI data abort: 0 - not supported 1 - supported
      [10] CMD_CCC_DEFBYTE — CCC with defining byte: 0 - not supported 1 - supported
      [7] HDR_TS_EN — HDR-Ternary transfers: 0 - not supported 1 - supported
      [6] HDR_DDR_EN — HDR-DDR transfers: 0 - not supported 1 - supported
      [5] STANDBY_CR_CAP — Switching from active to standby mode: 0 - not supported, this controller is always active on I3C 1- supported, this controller can hand off I3C to secondary controller
      [3] AUTO_COMMAND — Automatic read command on IBI: 0 - not supported 1 - supported
      [2] COMBO_COMMAND — Controller combined command: 0 - not supported 1 - supported
    0x10 RESET_CONTROL 32-bit — Requests a controller soft reset or selective PIO queue and FIFO resets. Reset requests are self-clearing.
      [5] IBI_QUEUE_RST — Clear IBI queue from software. Valid only in PIO mode.
      [4] RX_FIFO_RST — Clear RX FIFO from software. Valid only in PIO mode.
      [3] TX_FIFO_RST — Clear TX FIFO from software. Valid only in PIO mode.
      [2] RESP_QUEUE_RST — Clear response queue from software. Valid only in PIO mode.
      [1] CMD_QUEUE_RST — Clear command queue from software. Valid only in PIO mode.
      [0] SOFT_RST — Reset controller from software. Not supported currently
    0x14 PRESENT_STATE 32-bit ro — Reports current controller state, including active-controller bus ownership.
      [2] AC_CURRENT_OWN — Controller I3C state: 0 - not bus owner 1 - bus owner
    0x20 INTR_STATUS 32-bit — Reports host-controller error and exceptional-condition status.
      [14] SCHED_CMD_MISSED_TICK_STAT write-1-clears — Scheduled commands could be executed due to controller being busy.
      [13] HC_ERR_CMD_SEQ_TIMEOUT_STAT write-1-clears — Command timeout after prolonged stall.
      [12] HC_WARN_CMD_SEQ_STALL_STAT write-1-clears — Clock stalled due to lack of commands.
      [11] HC_SEQ_CANCEL_STAT write-1-clears — Controller had to cancel command sequence.
      [10] HC_INTERNAL_ERR_STAT write-1-clears — Controller internal unrecoverable error.
    0x24 INTR_STATUS_ENABLE 32-bit — Enables individual host-controller interrupt status sources.
      [14] SCHED_CMD_MISSED_TICK_STAT_EN — Enable SCHED_CMD_MISSED_TICK_STAT monitoring.
      [13] HC_ERR_CMD_SEQ_TIMEOUT_STAT_EN — Enable HC_ERR_CMD_SEQ_TIMEOUT_STAT monitoring.
      [12] HC_WARN_CMD_SEQ_STALL_STAT_EN — Enable HC_WARN_CMD_SEQ_STALL_STAT monitoring.
      [11] HC_SEQ_CANCEL_STAT_EN — Enable HC_SEQ_CANCEL_STAT monitoring.
      [10] HC_INTERNAL_ERR_STAT_EN — Enable HC_INTERNAL_ERR_STAT monitoring.
    0x28 INTR_SIGNAL_ENABLE 32-bit — Routes enabled host-controller interrupt sources to the interrupt output.
      [14] SCHED_CMD_MISSED_TICK_SIGNAL_EN — Enable SCHED_CMD_MISSED_TICK_STAT interrupt.
      [13] HC_ERR_CMD_SEQ_TIMEOUT_SIGNAL_EN — Enable HC_ERR_CMD_SEQ_TIMEOUT_STAT interrupt.
      [12] HC_WARN_CMD_SEQ_STALL_SIGNAL_EN — Enable HC_WARN_CMD_SEQ_STALL_STAT interrupt.
      [11] HC_SEQ_CANCEL_SIGNAL_EN — Enable HC_SEQ_CANCEL_STAT interrupt.
      [10] HC_INTERNAL_ERR_SIGNAL_EN — Enable HC_INTERNAL_ERR_STAT interrupt.
    0x2C INTR_FORCE 32-bit wo — Forces host-controller interrupts for software testing.
      [14] SCHED_CMD_MISSED_TICK_FORCE — Force SCHED_CMD_MISSED_TICK_STAT interrupt.
      [13] HC_ERR_CMD_SEQ_TIMEOUT_FORCE — Force HC_ERR_CMD_SEQ_TIMEOUT_STAT interrupt.
      [12] HC_WARN_CMD_SEQ_STALL_FORCE — Force HC_WARN_CMD_SEQ_STALL_STAT interrupt.
      [11] HC_SEQ_CANCEL_FORCE — Force HC_SEQ_CANCEL_STAT interrupt.
      [10] HC_INTERNAL_ERR_FORCE — Force HC_INTERNAL_ERR_STAT interrupt.
    0x30 DAT_SECTION_OFFSET 32-bit ro reset 0x7F400 — Reports the Device Address Table section offset and size.
      [31:28] ENTRY_SIZE — Individual DAT entry size. 0 - 2 DWRODs, 1:15 - reserved.
      [18:12] TABLE_SIZE — Max number of DAT entries.
      [11:0] TABLE_OFFSET — DAT entry offset in respect to BASE address.
    0x34 DCT_SECTION_OFFSET 32-bit access per field reset 0x7F800 — Configures the Device Characteristic Table section offset, size, and ENTDAA index.
      [31:28] ENTRY_SIZE ro — Individual DCT entry size. 0 - 4 DWORDs, 1:15 - Reserved.
      [23:19] TABLE_INDEX rw — Index to DCT used during ENTDAA.
      [18:12] TABLE_SIZE ro — Max number of DCT entries.
      [11:0] TABLE_OFFSET ro — DCT entry offset in respect to BASE address.
    0x38 RING_HEADERS_SECTION_OFFSET 32-bit ro — Ring section offset
      [15:0] SECTION_OFFSET — DMA ring headers section offset. Invalid if 0.
    0x3C PIO_SECTION_OFFSET 32-bit ro reset 0x80 — Reports the PIO section offset.
      [15:0] SECTION_OFFSET — PIO section offset. Invalid if 0.
    0x40 EXT_CAPS_SECTION_OFFSET 32-bit ro reset 0x100 — Extended capabilities section offset
      [15:0] SECTION_OFFSET — Extended Capabilities section offset. Invalid if 0.
    0x4C INT_CTRL_CMDS_EN 32-bit ro reset 0x6B — MIPI commands
      [15:1] MIPI_CMDS_SUPPORTED — Bitmask of supported MIPI commands.
      [0] ICC_SUPPORT — Internal Control Commands: 1 - some or all internals commands sub-commands are supported, 0 - illegal.
    0x58 IBI_NOTIFY_CTRL 32-bit — I3C interrupts notification
      [3] NOTIFY_IBI_REJECTED — Notify about rejected IBI: 0 - do not enqueue rejected IBI, 1 = enqueue rejected IBI on IBI queue/ring.
      [1] NOTIFY_CRR_REJECTED — Notify about rejected controller role request: 0 - do not enqueue rejected CRR, 1 = enqueue rejected CRR on IBI queue/ring.
      [0] NOTIFY_HJ_REJECTED — Notify about rejected hot-join: 0 - do not enqueue rejected HJ, 1 = enqueue rejected HJ on IBI queue/ring.
    0x5C IBI_DATA_ABORT_CTRL 32-bit — IBI data control
      [31] IBI_DATA_ABORT_MON — Enable/disable IBI monitoring logic.
      [20:18] MATCH_STATUS_TYPE — Define which IBI should be aborted: 3'b000 - Regular IBI, 3'b100 - Autocmd IBI, other values - not supported.
      [17:16] AFTER_N_CHUNKS — Number of data chunks to be allowed before forced termination: 0 - immediate, 1:3 - delay by 1-3 data chunks.
      [15:8] MATCH_IBI_ID — IBI target address: [15:9] - device address, [8] - must always be set to 1'b1
    0x60 DEV_CTX_BASE_LO 32-bit — Device context memory address lower 32 bits
      [0] BASE_LO
    0x64 DEV_CTX_BASE_HI 32-bit — Device context memory address higher 32 bits
      [0] BASE_HI
    0x68 DEV_CTX_SG 32-bit ro — SG control
      [31] BLP — Buffer vs list pointer in device context: 0 - continuous physical memory region, 1 - pointer to SG descriptor list.
      [15:0] LIST_SIZE — Number of SG entries.
  0x80 PIOControl group
    0x00 COMMAND_PORT 32-bit wo reset not defined — Accepts a 64-bit command descriptor as two consecutive 32-bit writes. The second write enqueues the descriptor.
      [31:0] COMMAND_DATA — COMMAND_QUEUE_PORT
    0x04 RESPONSE_PORT 32-bit ro reset not defined — Returns one 32-bit response descriptor from the response queue.
      [31:0] RESPONSE_DATA — RESPONSE_QUEUE_PORT
    0x08 TX_DATA_PORT 32-bit wo reset not defined — Writes transmit data to the TX FIFO. This port shares its address with the read-only RX data port.
      [31:0] TX_DATA
    0x08 RX_DATA_PORT 32-bit ro reset not defined — Reads received data from the RX FIFO. This port shares its address with the write-only TX data port.
      [31:0] RX_DATA
    0x0C IBI_PORT 32-bit ro reset not defined — Returns IBI status and payload data. Payload data is padded to a 4-byte boundary.
      [31:0] IBI_DATA — Data Read from IBI Data Buffer. The IBI Port is mapped to the IBI Data Queue. IBI Data is always aligned to a 4-byte boundary and then put into the IBI Queue. If the incoming data is not aligned to a 4-byte boundary, then there will be extra (unused) bytes at the end of the transferred IBI data. This can be determined from the value of field DATA_LENGTH in the IBI Status Descriptor.
    0x10 QUEUE_THLD_CTRL 32-bit reset 0x1010101 — Configures command, response, and IBI queue thresholds as raw entry counts.
      [31:24] IBI_STATUS_THLD — Triggers IBI_STATUS_THLD_STAT interrupt when IBI queue has N or more entries. Accepted values are 1:255
      [23:16] IBI_DATA_SEGMENT_SIZE — IBI Queue data segment size. Valida values are 1:63
      [15:8] RESP_BUF_THLD — Triggers RESP_READY_STAT interrupt when RESP queue has N or more entries. Accepted values are 1:255
      [7:0] CMD_EMPTY_BUF_THLD — Triggers CMD_QUEUE_READY_STAT interrupt when CMD queue has N or more free entries. Accepted values are 1:255
    0x14 DATA_BUFFER_THLD_CTRL 32-bit reset 0x1010101 — Configures TX and RX start and ready thresholds, each encoding 2^(N+1) entries.
      [26:24] RX_START_THLD — Postpone read command until RX queue has 2^(N+1) free entries
      [18:16] TX_START_THLD — Postpone write command until TX queue has 2^(N+1) entries
      [10:8] RX_BUF_THLD — Trigger RX_THLD_STAT interrupt when RX queue has 2^(N+1) or more entries
      [2:0] TX_BUF_THLD — Trigger TX_THLD_STAT interrupt when TX queue has 2^(N+1) or more free entries
    0x18 QUEUE_SIZE 32-bit ro reset 0x5052040 — Reports command, response, IBI, TX, and RX queue depths.
      [31:24] TX_DATA_BUFFER_SIZE — TX queue size is equal to 2^(N+1), where N is this field value
      [23:16] RX_DATA_BUFFER_SIZE — RX queue size is equal to 2^(N+1), where N is this field value
      [15:8] IBI_STATUS_SIZE — IBI Queue size is equal to N
      [7:0] CR_QUEUE_SIZE — Command/Response queue size is equal to N
    0x1C ALT_QUEUE_SIZE 32-bit ro reset 0x1000020 — Reports extended IBI and alternate response queue sizes.
      [28] EXT_IBI_QUEUE_EN — 1 indicates that IBI queue size is equal to 8*IBI_STATUS_SIZE
      [24] ALT_RESP_QUEUE_EN — If set, response and command queues are not equal lengths, then ALT_RESP_QUEUE_SIZE contains response queue size
      [7:0] ALT_RESP_QUEUE_SIZE — Valid only if ALT_RESP_QUEUE_EN is set. Contains response queue size
    0x20 PIO_INTR_STATUS 32-bit access per field — Reports PIO queue-threshold and transfer-event interrupt status.
      [9] TRANSFER_ERR_STAT rw write-1-clears — Transfer error
      [5] TRANSFER_ABORT_STAT rw write-1-clears — Transfer aborted
      [4] RESP_READY_STAT ro — Response queue fulfils RESP_BUF_THLD
      [3] CMD_QUEUE_READY_STAT ro — Command queue fulfils CMD_EMPTY_BUF_THLD
      [2] IBI_STATUS_THLD_STAT ro — IBI queue fulfils IBI_STATUS_THLD
      [1] RX_THLD_STAT ro — RX queue fulfils RX_BUF_THLD
      [0] TX_THLD_STAT ro — TX queue fulfils TX_BUF_THLD
    0x24 PIO_INTR_STATUS_ENABLE 32-bit — Enables individual PIO interrupt status sources.
      [9] TRANSFER_ERR_STAT_EN — Enable transfer error monitoring
      [5] TRANSFER_ABORT_STAT_EN — Enable transfer abort monitoring
      [4] RESP_READY_STAT_EN — Enable response queue monitoring
      [3] CMD_QUEUE_READY_STAT_EN — Enable command queue monitoring
      [2] IBI_STATUS_THLD_STAT_EN — Enable IBI queue monitoring
      [1] RX_THLD_STAT_EN — Enable RX queue monitoring
      [0] TX_THLD_STAT_EN — Enable TX queue monitoring
    0x28 PIO_INTR_SIGNAL_ENABLE 32-bit — Routes enabled PIO interrupt sources to the interrupt output.
      [9] TRANSFER_ERR_SIGNAL_EN — Enable transfer error interrupt
      [5] TRANSFER_ABORT_SIGNAL_EN — Enable transfer abort interrupt
      [4] RESP_READY_SIGNAL_EN — Enable response ready interrupt
      [3] CMD_QUEUE_READY_SIGNAL_EN — Enable command queue interrupt
      [2] IBI_STATUS_THLD_SIGNAL_EN — Enable IBI queue interrupt
      [1] RX_THLD_SIGNAL_EN — Enable RX queue interrupt
      [0] TX_THLD_SIGNAL_EN — Enable TX queue interrupt
    0x2C PIO_INTR_FORCE 32-bit wo — PIO force interrupt status
      [9] TRANSFER_ERR_FORCE — Force transfer error
      [5] TRANSFER_ABORT_FORCE — Force transfer aborted
      [4] RESP_READY_FORCE — Force response queue interrupt
      [3] CMD_QUEUE_READY_FORCE — Force command queue interrupt
      [2] IBI_THLD_FORCE — Force IBI queue interrupt
      [1] RX_THLD_FORCE — Force RX queue interrupt
      [0] TX_THLD_FORCE — Force TX queue interrupt
    0x30 PIO_CONTROL 32-bit reset 0x1 — Controls run/stop and forced abort of enqueued commands.
      [2] ABORT — Stop current command descriptor execution forcefully and hold remaining commands. 1 - Request PIO Abort, 0 - Resume PIO execution
      [1] RS — Run/Stop execution of enqueued commands. When set to 0, it holds execution of enqueued commands and runs current command to completion. 1 - PIO Queue start request, 0 - PIO Queue stop request.
      [0] ENABLE — Enables PIO queues. When disabled, SW may not read from/write to PIO queues. 1 - PIO queue enable request, 0 - PIO queue disable request
  0x100 I3C_EC group
    0x00 SecFwRecoveryIf group
      0x00 EXTCAP_HEADER 32-bit ro reset 0x20C0
        [23:8] CAP_LENGTH — Capability Structure Length in DWORDs
        [7:0] CAP_ID — Extended Capability ID
      0x04 PROT_CAP_0 32-bit ro reset 0x2050434F — Recovery Protocol Capabilities 0
        [31:0] REC_MAGIC_STRING_0 — Magic string 'OCP ' (1st part of 'OCP RECV') in ASCII code - '0x4f 0x43 0x50 0x20'
      0x08 PROT_CAP_1 32-bit ro reset 0x56434552 — Recovery Protocol Capabilities 1
        [31:0] REC_MAGIC_STRING_1 — Magic string 'RECV' (2nd part of 'OCP RECV') in ASCII code - '0x52 0x45 0x43 0x56'
      0x0C PROT_CAP_2 32-bit — Recovery Protocol Capabilities 2
        [31:16] AGENT_CAPS — Agent capabilities: * bit 0: Identification (DEVICE_ID structure) * bit 1: Forced Recovery (From RESET) * bit 2: Mgmt reset (From RESET) * bit 3: Device Reset (From RESET) * bit 4: Device status (DEVICE_STATUS) * bit 5: Recovery memory access (INDIRECT_CTRL) * bit 6: Local C-image support * bit 7: Push C-image support * bit 8: Interface isolation * bit 9: Hardware status * bit 10: Vendor command * bit 11: Flashless boot (From RESET) * bit 12: FIFO CMS support (INDIRECT_FIFO_CTRL) * bits 13-15: Reserved
        [15:0] REC_PROT_VERSION — * Byte 0: Major version number = 0x1 * Byte 1: Minor version number = 0x1
      0x10 PROT_CAP_3 32-bit — Recovery Protocol Capabilities 3
        [23:16] HEARTBEAT_PERIOD — 0-255: Heartbeat period, 2^x microseconds (us), 0 indicates not supported
        [15:8] MAX_RESP_TIME — 0-255: Maximum response time in 2^x microseconds(us).
        [7:0] NUM_OF_CMS_REGIONS — 0-255: The total number of component memory space (CMS) regions a device supports. This number includes any logging, code and vendor defined regions
      0x14 DEVICE_ID_0 32-bit — Device Identification 0
        [31:16] DATA
        [15:8] VENDOR_SPECIFIC_STR_LENGTH — 0x0-0xFF: Total length of Vendor Specific String, 0 indicates not supported
        [7:0] DESC_TYPE — Based on table 8 from [DMTF PLDM FM]: * 0x00: PCI Vendor * 0x1: IANA * 0x2: UUID * 0x3: PnP Vendor * 0x4: ACPI Vendor * 0x5: IANA Enterprise Type * 0x6-0xFE: Reserved * 0xFF: NVMe-MI
      {0x14+4l} DEVICE_ID_{l} 32-bit (l=1..5) — Device Identification {l}
        [31:0] DATA
      0x2C DEVICE_ID_RESERVED 32-bit ro — Reserved
        [31:0] DATA
      0x30 DEVICE_STATUS_0 32-bit
        [31:16] REC_REASON_CODE — * 0x0: No Boot Failure detected (BFNF) * 0x1: Generic hardware error (BFGHWE) * 0x2: Generic hardware soft error (BFGSE) - soft error may be recoverable * 0x3: Self-test failure (BFSTF) (e.g., RSA self test failure, FIPs self test failure,, etc.) * 0x4: Corrupted/missing critical data (BFCD) * 0x5: Missing/corrupt key manifest (BFKMMC) * 0x6: Authentication Failure on key manifest (BFKMAF) * 0x7: Anti-rollback failure on key manifest (BFKIAR) * 0x8: Missing/corrupt boot loader (first mutable code) firmware image (BFFIMC) * 0x9: Authentication failure on boot loader ( 1st mutable code) firmware image (BFFIAF) * 0xA: Anti-rollback failure boot loader (1st mutable code) firmware image (BFFIAR) * 0xB: Missing/corrupt main/management firmware image (BFMFMC) * 0xC: Authentication Failure main/management firmware image (BFMFAF) * 0xD: Anti-rollback Failure main/management firmware image (BFMFAR) * 0xE: Missing/corrupt recovery firmware (BFRFMC) * 0xF: Authentication Failure recovery firmware (BFRFAF) * 0x10: Anti-rollback Failure on recovery firmware (BFRFAR) * 0x11: Forced Recovery (FR) * 0x12: Flashless/Streaming Boot (FSB) * 0x13-0x7F: Reserved * 0x80-0xFF: Vendor Unique Boot Failure Codes
        [15:8] PROT_ERROR read-clears — * 0x0: No Protocol Error * 0x1: Unsupported/Write Command - command is not support or a write to a RO command * 0x2: Unsupported Parameter * 0x3: Length write error (length of write command is incorrect) * 0x4: CRC Error (if supported) * 0x5-0xFE: Reserved * 0xFF: General Protocol Error - catch all unclassified errors
        [7:0] DEV_STATUS — * 0x0: Status Pending (Recover Reason Code not populated) * 0x1: Device healthy (Recover Reason Code not populated) * 0x2: Device Error (“soft” error or other error state) - (Recover Reason Code not populated) * 0x3: Recovery mode - ready to accept recovery image - (Recover Reason Code populated) * 0x4: Recovery Pending (waiting for activation) - (Recover Reason Code populated) * 0x5: Running Recovery Image ( Recover Reason Code not populated) * 0x6-0xD: Reserved * 0xE: Boot Failure (Recover Reason Code populated) * 0xF: Fatal Error (Recover Reason Code not populated) * 0x10-FF:Reserved
      0x34 DEVICE_STATUS_1 32-bit
        [31:25] VENDOR_STATUS — Vendor defined status message
        [24:16] VENDOR_STATUS_LENGTH — 0-248: Length in bytes of just VENDOR_STATUS. Zero indicates no vendor status and zero additional bytes.
        [15:0] HEARTBEAT — 0-4095: Incrementing number (counter wraps)
      0x38 DEVICE_RESET 32-bit — For devices which support reset, this register will reset the device or management entity
        [23:16] IF_CTRL — * 0x0: Disable Interface mastering * 0x1: Enable Interface mastering
        [15:8] FORCED_RECOVERY — * 0x0: No forced recovery * 0x01-0xD: Reserved * 0xE: Enter flashless boot mode on next platform reset * 0xF: Enter recovery mode on next platform reset * 0x10-FF: Reserved
        [7:0] RESET_CTRL write-1-clears — * 0x0: No reset * 0x1: Reset Device (PCIe Fundamental Reset or equivalent. This is likely bus disruptive) * 0x2: Reset Management. This reset will reset the management subsystem. If supported, this reset MUST not be bus disruptive (cause re-enumeration) * 0x3-FF: Reserved
      0x3C RECOVERY_CTRL 32-bit — Recovery configuration/control
        [23:16] ACTIVATE_REC_IMG write-1-clears — * 0x0: do not activate recovery image - after activation device will report this code. * 0xF: Activate recovery image * 0x10-FF-reserved
        [15:8] REC_IMG_SEL — * 0x0: No operation * 0x1: Use Recovery Image from memory window (CMS) * 0x2: Use Recovery Image stored on device (C-image) * 0x3-FF: reserved
        [7:0] CMS — * 0-255: Selects a component memory space where the recovery image is. 0 is the default
      0x40 RECOVERY_STATUS 32-bit
        [15:8] VENDOR_SPECIFIC_STATUS
        [7:4] REC_IMG_INDEX — Recovery image index
        [3:0] DEV_REC_STATUS — * 0x0: Not in recovery mode * 0x1: Awaiting recovery image * 0x2: Booting recovery image * 0x3: Recovery successful * 0xc: Recovery failed * 0xd: Recovery image authentication error * 0xe: Error entering Recovery mode (might be administratively disabled) * 0xf: Invalid component address space
      0x44 HW_STATUS 32-bit — Hardware status
        [31:24] VENDOR_HW_STATUS_LEN — 0-251: Length in bytes of Vendor Specific Hardware Status.
        [23:16] CTEMP — Current temperatureof device in degrees Celsius: Compatible with NVMe-MI command code 0 offset 3. * 0x00-0x7e: 0 to 126 C * 0x7f: 127 C or higher * 0x80: no temperature data, or data is older than 5 seconds * 0x81: temperature sensor failure * 0x82-0x83: reserved * 0xc4: -60 C or lower * 0xc5-0xff: -59 to -1 C (in two's complement)
        [15:8] VENDOR_HW_STATUS — Vendor HW Status (bit mask active high)
        [2] FATAL_ERR — Hardware Fatal Error
        [1] SOFT_ERR — Hardware Soft Error (may need reset to clear)
        [0] TEMP_CRITICAL — Device temperature is critical (may need reset to clear)
      0x48 INDIRECT_FIFO_CTRL_0 32-bit — Indirect FIFO Control 0
        [15:8] RESET — Reset (Write 1 Clear): * 0x0: idle * 0x1: reset Write Index and Read Index to initial value. * 0x2 to 0xFF: reserved
        [7:0] CMS — This register selects a region within the device. Read/write access is through address spaces. Each space represents a FIFO. Component Memory Space (CMS): * 0-255: Address region within a device.
      0x4C INDIRECT_FIFO_CTRL_1 32-bit — Indirect FIFO Control 1
        [31:0] IMAGE_SIZE — Image Size: Size of the image to be loaded in 4B units
      0x50 INDIRECT_FIFO_STATUS_0 32-bit ro reset 0x1
        [10:8] REGION_TYPE — Memory Region Type: * 0b000: Code space for recovery. (write only) * 0b001: Log uses the defined debug format (read only) * 0b100: Vendor Defined Region (write only) * 0b101: Vendor Defined Region (read only) * 0b111: Unsupported Region (address space out of range)
        [1] FULL — If set, FIFO is full
        [0] EMPTY — If set, FIFO is empty
      0x54 INDIRECT_FIFO_STATUS_1 32-bit ro
        [31:0] WRITE_INDEX — Offset incremented for each access by the Recovery Agent in 4B units
      0x58 INDIRECT_FIFO_STATUS_2 32-bit ro
        [31:0] READ_INDEX — Offset incremented for each access by the device in 4B units
      0x5C INDIRECT_FIFO_STATUS_3 32-bit ro reset 0x40
        [31:0] FIFO_SIZE — Size of memory window specified in 4B units. Current implementation supports only a constant size of 64.
      0x60 INDIRECT_FIFO_STATUS_4 32-bit ro reset 0x40
        [31:0] MAX_TRANSFER_SIZE — Max size of the data payload in each read/write to INDIRECT_FIFO_DATA in 4B units Enforced to 256 bytes (64 DWORDs) by Caliptra Subsystem Recovery Sequence
      0x64 INDIRECT_FIFO_RESERVED 32-bit ro
        [31:0] DATA — Reserved register
      0x68 INDIRECT_FIFO_DATA 32-bit ro — Indirect memory access to address space configured in INDIRECT_FIFO_CTRL at the Head Pointer offset.
    0x80 StdbyCtrlMode group
      0x00 EXTCAP_HEADER 32-bit ro reset 0x2012
        fields as i3c_csr[0].I3C_EC.SecFwRecoveryIf.EXTCAP_HEADER
      0x04 STBY_CR_CONTROL 32-bit access per field reset 0x1000 — Configures standby-controller operation, dynamic-address-assignment methods, target transactions, and controller-role handoff.
        [31:30] STBY_CR_ENABLE_INIT rw — Enables or disables the Secondary Controller: 2'b00 - DISABLED: Secondary Controller is disabled. 2'b01 - ACM_INIT: Secondary Controller is enabled, but Host Controller initializes in Active Controller mode. 2'b10 - SCM_RUNNING: Secondary Controller operation is enabled, Host Controller initializes in Standby Controller mode. 2'b11 - SCM_HOT_JOIN: Secondary Controller operation is enabled, Host Controller conditionally becomes a Hot-Joining Device to receive its Dynamic Address before operating in Standby Controller mode.
        [20] RSTACT_DEFBYTE_02 rw — Controls whether I3C Secondary Controller Logic supports RSTACT CCC with Defining Byte 0x02. 1'b0: NOT_SUPPORTED: Do not ACK Defining Byte 0x02 1'b1: HANDLE_INTR: Support Defining Byte 0x02
        [15] DAA_ENTDAA_ENABLE rw — Indicates ENTDAA method is enabled. 1'b0: DISABLED: will not respond 1'b1: ENABLED: will respond
        [14] DAA_SETDASA_ENABLE rw — Indicates SETDASA method is enabled. 1'b0: DISABLED: will not respond 1'b1: ENABLED: will respond
        [13] DAA_SETAASA_ENABLE rw — Indicates SETAASA method is enabled. 1'b0: DISABLED: will not respond 1'b1: ENABLED: will respond
        [12] TARGET_XACT_ENABLE rw — Indicates whether Read-Type/Write-Type transaction servicing is enabled, via an I3C Target Transaction Interface to software (Section 6.17.3). 1'b0: DISABLED: not available 1'b1: ENABLED: available for software
        [10:8] BAST_CCC_IBI_RING rw — Indicates which Ring Bundle will be used to capture Broadcast CCC data sent by the Active Controller. The Ring Bundle must be configured and enabled, and its IBI Ring Pair must also be initialized and ready to receive data.
        [5] CR_REQUEST_SEND wo — Write of 1'b1 to this field shall instruct the Secondary Controller Logic to attempt to send a Controller Role Request to the I3C Bus.
        [4] HANDOFF_DEEP_SLEEP rw write-sets — If this field has a value of 1'b1, then the Secondary Controller Logic shall report a return from Deep Sleep state to the Active Controller. Writing 1'b1 to this bit is sticky. This field shall automatically clear to 1'b0 after accepting the Controller Role and transitioning to Active Controller mode.
        [3] PRIME_ACCEPT_GETACCCR rw — Prime to Accept Controller Role
        [2] ACR_FSM_OP_SELECT rw — Active Controller Select
        [1] HANDOFF_DELAY_NACK rw
        [0] PENDING_RX_NACK rw
      0x08 STBY_CR_DEVICE_ADDR 32-bit — Configures standby-controller dynamic and static addresses.
        [31] DYNAMIC_ADDR_VALID — Indicates whether or not the value in the DYNAMIC_ADDR field is valid. 1'b0: DYNAMIC_ADDR field is not valid 1'b1: DYNAMIC_ADDR field is valid
        [22:16] DYNAMIC_ADDR — Contains the Host Controller Device’s Dynamic Address.
        [15] STATIC_ADDR_VALID — Indicates whether or not the value in the STATIC_ADDR field is valid. 1'b0: The Static Address field is not valid 1'b1: The Static Address field is valid
        [6:0] STATIC_ADDR — This field contains the Host Controller Device’s Static Address.
      0x0C STBY_CR_CAPABILITIES 32-bit ro reset 0x7000 — Reports standby-controller capabilities.
        [15] DAA_ENTDAA_SUPPORT — Defines whether Dynamic Address Assignment with ENTDAA CCC is supported. 1'b0: DISABLED: Not supported 1'b1: ENABLED: Supported
        [14] DAA_SETDASA_SUPPORT — Defines whether Dynamic Address Assignment with SETDASA CCC (using Static Address) is supported. 1'b0: DISABLED: Not supported 1'b1: ENABLED: Supported
        [13] DAA_SETAASA_SUPPORT — Defines whether Dynamic Address Assignment with SETAASA CCC (using Static Address) is supported. 1'b0: DISABLED: Not supported 1'b1: ENABLED: Supported
        [12] TARGET_XACT_SUPPORT — Defines whether an I3C Target Transaction Interface is supported. 1'b0: DISABLED: Not supported 1'b1: ENABLED: Supported via vendor-defined Extended Capability structure
        [5] SIMPLE_CRR_SUPPORT
      0x10 STBY_CR_VIRTUAL_DEVICE_CHAR 32-bit reset 0x30BDFFFE — Standby Controller Virtual Device Characteristics
        [31:29] BCR_FIXED — Bus Characteristics, Fixed Part. Reset value is set to 3'b001, because this device is an I3C Target, which supports extended capabilities. This field is Read-Only while the STBY_CR_ENABLE_INIT field in register STBY_CR_CONTROL is not zero.
        [28:24] BCR_VAR — Bus Characteristics, Variable Part. Reset value is set to 5'b10000, because this device: - [bit4] is a Virtual Target - [bit3] is not Offline Capable - [bit2] does not apply due to bit1 - [bit1] is not capable of IBI requests - [bit0] has no speed limitation This field is Read-Only while the STBY_CR_ENABLE_INIT field in register STBY_CR_CONTROL is not zero.
        [23:16] DCR — Device Characteristics Register. Value represents an OCP Recovery Device. This field is Read-Only while the STBY_CR_ENABLE_INIT field in register STBY_CR_CONTROL is not zero.
        [15:1] PID_HI — High part of the 48-bit Target Device Provisioned ID. This field is Read-Only while the STBY_CR_ENABLE_INIT field in register STBY_CR_CONTROL is not zero.
      0x14 STBY_CR_STATUS 32-bit — Standby Controller Status
        [8] HJ_REQ_STATUS, [7:5] SIMPLE_CRR_STATUS, [2] AC_CURRENT_OWN
      0x18 STBY_CR_DEVICE_CHAR 32-bit reset 0x36BDFFFE — Standby Controller Device Characteristics
        [31:29] BCR_FIXED — Bus Characteristics, Fixed Part. Reset value is set to 3'b001, because this device is an I3C Target, which supports extended capabilities This field is Read-Only while the STBY_CR_ENABLE_INIT field in register STBY_CR_CONTROL is not zero.
        [28:24] BCR_VAR — Bus Characteristics, Variable Part. Reset value is set to 5'b10110, because this device: - [bit4] exposes a Virtual Target - [bit3] is not Offline Capable - [bit2] (always) uses the MDB in the IBI Payload - [bit1] is capable of IBI requests - [bit0] has no speed limitation This field is Read-Only while the STBY_CR_ENABLE_INIT field in register STBY_CR_CONTROL is not zero.
        [23:16] DCR — Device Characteristics Register. Value represents an OCP Recovery Device. This field is Read-Only while the STBY_CR_ENABLE_INIT field in register STBY_CR_CONTROL is not zero.
        [15:1] PID_HI — High part of the 48-bit Target Device Provisioned ID. This field is Read-Only while the STBY_CR_ENABLE_INIT field in register STBY_CR_CONTROL is not zero.
      0x1C STBY_CR_DEVICE_PID_LO 32-bit reset 0x5A00A5 — Standby Controller Device PID Low
        [31:0] PID_LO — Low part of the 48-bit Target Device Provisioned ID. This field is Read-Only while the STBY_CR_ENABLE_INIT field in register STBY_CR_CONTROL is not zero.
      0x20 STBY_CR_INTR_STATUS 32-bit — Standby Controller Interrupt Status
        [19] CCC_FATAL_RSTDAA_ERR_STAT
        [18] CCC_UNHANDLED_NACK_STAT
        [17] CCC_PARAM_MODIFIED_STAT
        [16] STBY_CR_OP_RSTACT_STAT — The Host Controller shall write 1'b1 to this field to indicate that the Secondary Controller received a RSTACT CCC from the Active Controller, followed by the Target Reset Pattern.
        [14] STBY_CR_ACCEPT_ERR_STAT
        [13] STBY_CR_ACCEPT_OK_STAT
        [12] STBY_CR_ACCEPT_NACKED_STAT
        [11] STBY_CR_DYN_ADDR_STAT
        [10] CRR_RESPONSE_STAT
        [3] ACR_HANDOFF_ERR_M3_STAT
        [2] ACR_HANDOFF_ERR_FAIL_STAT
        [1] ACR_HANDOFF_OK_PRIMED_STAT
        [0] ACR_HANDOFF_OK_REMAIN_STAT
      0x24 STBY_CR_VIRTUAL_DEVICE_PID_LO 32-bit reset 0x5A10A5 — Standby Controller Virtual Device PID Low
        [31:0] PID_LO — Low part of the 48-bit Target Virtual Device Provisioned ID. This field is Read-Only while the STBY_CR_ENABLE_INIT field in register STBY_CR_CONTROL is not zero.
      0x28 STBY_CR_INTR_SIGNAL_ENABLE 32-bit — When set to 1'b1, and the corresponding interrupt status field is set in register STBY_CR_INTR_STATUS, the Host Controller shall assert an interrupt to the Host.
        [19] CCC_FATAL_RSTDAA_ERR_SIGNAL_EN, [18] CCC_UNHANDLED_NACK_SIGNAL_EN, [17] CCC_PARAM_MODIFIED_SIGNAL_EN, [16] STBY_CR_OP_RSTACT_SIGNAL_EN, [14] STBY_CR_ACCEPT_ERR_SIGNAL_EN, [13] STBY_CR_ACCEPT_OK_SIGNAL_EN, [12] STBY_CR_ACCEPT_NACKED_SIGNAL_EN, [11] STBY_CR_DYN_ADDR_SIGNAL_EN, [10] CRR_RESPONSE_SIGNAL_EN, [3] ACR_HANDOFF_ERR_M3_SIGNAL_EN, [2] ACR_HANDOFF_ERR_FAIL_SIGNAL_EN, [1] ACR_HANDOFF_OK_PRIMED_SIGNAL_EN, [0] ACR_HANDOFF_OK_REMAIN_SIGNAL_EN
      0x2C STBY_CR_INTR_FORCE 32-bit access per field — For software testing, when set to 1'b1, forces the corresponding interrupt to be sent to the Host, if the corresponding fields are set in register STBY_CR_INTR_SIGNAL_ENABLE
        [19] CCC_FATAL_RSTDAA_ERR_FORCE rw, [18] CCC_UNHANDLED_NACK_FORCE rw, [17] CCC_PARAM_MODIFIED_FORCE rw, [16] STBY_CR_OP_RSTACT_FORCE wo, [14] STBY_CR_ACCEPT_ERR_FORCE rw, [13] STBY_CR_ACCEPT_OK_FORCE rw, [12] STBY_CR_ACCEPT_NACKED_FORCE rw, [11] STBY_CR_DYN_ADDR_FORCE rw, [10] CRR_RESPONSE_FORCE rw
      0x30 STBY_CR_CCC_CONFIG_GETCAPS 32-bit — Standby Controller CCC Configuration GETCAPS
        [11:8] F2_CRCAP2_DEV_INTERACT, [2:0] F2_CRCAP1_BUS_CONFIG
      0x34 STBY_CR_CCC_CONFIG_RSTACT_PARAMS 32-bit access per field reset 0x80000001 — Reports the defining byte of the last RSTACT CCC received and configures the reset recovery times.
        [31] RESET_DYNAMIC_ADDR rw — If set to 1'b1, then the Secondary Controller Logic must clear its Dynamic Address in register STBY_CR_DEVICE_ADDR after receiving a Target Reset Pattern that followed a Broadcast or Direct SET RSTACT CCC sent to the Dynamic Address, with Defining Byte 0x01 or 0x02. Requires support for Dynamic Address Assignment with at least one supported method, such as the ENTDAA CCC, with field DAA_ENTDAA_ENABLE set to 1'b1 in register STBY_CR_CONTROL. If field ACR_FSM_OP_SELECT in register STBY_CR_CONTROL is set to 1'b1, then this field shall be cleared (i.e., readiness to accept the Controller Role shall be revoked) with this Target Reset Pattern.
        [23:16] RESET_TIME_TARGET rw — For Direct GET CCC, this field is returned for Defining Byte 0x82.
        [15:8] RESET_TIME_PERIPHERAL rw — For Direct GET CCC, this field is returned for Defining Byte 0x81.
        [7:0] RST_ACTION ro — Contains the Defining Byte received with the last Direct SET CCC sent by the Active Controller. If not armed (START or RSTACT with unsupported defining byte) set to spec default 0x1.
      0x38 STBY_CR_VIRT_DEVICE_ADDR 32-bit — Standby Virtual Controller Device Address
        [31] VIRT_DYNAMIC_ADDR_VALID — Indicates whether or not the value in the VIRT_DYNAMIC_ADDR field is valid. 1'b0: VIRT_DYNAMIC_ADDR field is not valid 1'b1: VIRT_DYNAMIC_ADDR field is valid
        [22:16] VIRT_DYNAMIC_ADDR — Contains the Controller Virtual Device’s Dynamic Address.
        [15] VIRT_STATIC_ADDR_VALID — Indicates whether or not the value in the VIRT_STATIC_ADDR field is valid. 1'b0: The Virtual Device Static Address field is not valid 1'b1: The Virtual Device Static Address field is valid
        [6:0] VIRT_STATIC_ADDR — This field contains the Host Controller Device’s Static Address.
      0x3C STBY_CR_MWL 32-bit ro reset 0x100 — Standby Controller Maximum Write Length (read-only)
        [15:0] MWL — This field contains the maximum write length (MWL) (read-only)
      0x40 STBY_CR_MRL 32-bit ro reset 0x100100 — Standby Controller Maximum Read Length and IBI Payload Size (read-only)
        [23:16] IBIL — This field contains the IBI payload size (IBIL) (read-only)
        [15:0] MRL — This field contains the maximum read length (MRL) (read-only)
    0x100 TTI group
      0x00 EXTCAP_HEADER 32-bit ro reset 0x40C4
        fields as i3c_csr[0].I3C_EC.SecFwRecoveryIf.EXTCAP_HEADER
      0x04 CONTROL 32-bit reset 0x1400
        [15:13] IBI_RETRY_NUM — Number of times the Target Device will try to request an IBI before giving up. Values: 0x0 - Device will never retry. 0x1-0x6 - Device will retry this many times. 0x7 - Device will retry indefinitely until the Active Controller sets DISINT bit in the DISEC command.
        [12] IBI_EN — Enable the IBI queue servicing. Values: 0x0 - Device will not service the IBI queue. 0x1 - Device will send IBI requests onto the bus, if possible.
        [11] CRR_EN — Enable Controller Role Request. Values: 0x0 - Device is allowed to perform Controller Role Request. 0x1 - Device is not allowed to perform Controller Role Request.
        [10] HJ_EN — Enable Hot-Join capability. Values: 0x0 - Device is allowed to attempt Hot-Join. 0x1 - Device is not allowed to attempt Hot-Join.
      0x08 STATUS 32-bit ro
        [14:12] LAST_IBI_STATUS — Status of last IBI. Should be read after IBI_DONE interrupt. Values: 000 - Success: IBI was transmitted and ACK'd by the Active Controller. 001 - FailureNack: Active Controller NACK'd the IBI before any data was sent. The device will retry sending the IBI as long as permitted by the retry counter. 010 - FailurePartialData: Active Controller NACK'd the IBI after data was partially sent. The remaining part of data in the IBI queue is considered corrupted and will be discarded. 011 - FailureRetry: IBI could not be serviced due to reached retry count. 100 - FailureArbitration:: IBI could not be serviced as arbitration was lost during the address header. The device will retry sending the IBI as long as permitted by the retry counter.
        [8] PROTOCOL_ERROR — Protocol error occurred in the past. This field can only be reset by the Controller, if it issues the GETSTATUS CCC. Values: 0 - no error occurred 1 - generic protocol error occurred in the past. It will be set until reception of the next GETSTATUS command.
      0x0C RESET_CONTROL 32-bit access per field — Reset Control for Queues and IBI Retry Counter
        [6] IBI_RETRY_CTR_RST wo — TTI IBI Retry Counter Software Reset
        [5] IBI_QUEUE_RST rw — TTI IBI Queue Buffer Software Reset
        [4] RX_DATA_RST rw — TTI RX Data Queue Buffer Software Reset
        [3] TX_DATA_RST rw — TTI TX Data Queue Buffer Software Reset. Also resets the tti_conv_Nto8 since first dword is immediately loaded into the converter and can't be cleared otherwise.
        [2] RX_DESC_RST rw — TTI RX Descriptor Queue Buffer Software Reset
        [1] TX_DESC_RST rw — TTI TX Descriptor Queue Buffer Software Reset
        [0] SOFT_RST rw — Target Core Software Reset
      0x10 QUEUE_STATUS 32-bit ro reset 0x2AA — Dynamic queue full/empty status for debug and monitoring
        [9] IBI_QUEUE_EMPTY — IBI Queue is empty
        [8] IBI_QUEUE_FULL — IBI Queue is full
        [7] TX_DATA_QUEUE_EMPTY — TX Data Queue is empty
        [6] TX_DATA_QUEUE_FULL — TX Data Queue is full
        [5] RX_DATA_QUEUE_EMPTY — RX Data Queue is empty
        [4] RX_DATA_QUEUE_FULL — RX Data Queue is full
        [3] TX_DESC_QUEUE_EMPTY — TX Descriptor Queue is empty
        [2] TX_DESC_QUEUE_FULL — TX Descriptor Queue is full
        [1] RX_DESC_QUEUE_EMPTY — RX Descriptor Queue is empty
        [0] RX_DESC_QUEUE_FULL — RX Descriptor Queue is full
      0x14 DESC_QUEUE_DEPTH 32-bit ro — Current number of entries in descriptor queues
        [15:8] TX_DESC_QUEUE_DEPTH — Number of entries in TX Descriptor Queue
        [7:0] RX_DESC_QUEUE_DEPTH — Number of entries in RX Descriptor Queue
      0x18 DATA_QUEUE_DEPTH 32-bit ro — Current number of DWORD entries in data queues
        [15:8] TX_DATA_QUEUE_DEPTH — Number of DWORD entries in TX Data Queue
        [7:0] RX_DATA_QUEUE_DEPTH — Number of DWORD entries in RX Data Queue
      0x1C IBI_QUEUE_DEPTH 32-bit ro — Current number of entries in IBI queue
        [7:0] IBI_QUEUE_DEPTH — Number of entries in IBI Queue
      0x20 INTERRUPT_STATUS 32-bit access per field — Interrupt Status. How a bit is cleared depends on the bit: - Auto-cleared by hardware on a specific access: RX_DESC_STAT, RX_DESC_THLD_STAT and RX_DATA_THLD_STAT clear when software reads the corresponding RX queue; IBI_DONE clears when software reads STATUS.LAST_IBI_STATUS. These bits are also write-1-to-clear, but the normal servicing access clears them without an explicit write here. - Write-1-to-clear only (no hardware auto-clear): TX_DESC_COMPLETE, TX_DESC_STAT, TX_DESC_THLD_STAT, TX_DATA_THLD_STAT, IBI_THLD_STAT, and the not-implemented TRANSFER_ERR_STAT, TRANSFER_ABORT_STAT, TX_DESC_TIMEOUT, RX_DESC_TIMEOUT. Write 1 to the bit in this register to clear it. - Read-only, hardware-driven level status that cannot be cleared by software: PENDING_IBI and PENDING_INTERRUPT track live conditions.
        [31] TRANSFER_ERR_STAT rw write-1-clears — NOT IMPLEMENTED. Bus error occurred. Clear: write 1 to this bit in INTERRUPT_STATUS (no hardware auto-clear).
        [26] TX_DESC_COMPLETE rw write-1-clears — Read Transaction on the I3C Bus completed. Clear: write 1 to this bit in INTERRUPT_STATUS (no hardware auto-clear).
        [25] TRANSFER_ABORT_STAT rw write-1-clears — NOT IMPLEMENTED. Bus aborted transaction. Clear: write 1 to this bit in INTERRUPT_STATUS (no hardware auto-clear).
        [20] PENDING_IBI ro — At least one IBI is pending. Read-only, hardware-driven level status: it tracks the live IBI-pending condition and cannot be cleared by software (clears automatically when no IBI is pending).
        [19:16] PENDING_INTERRUPT rw — Contains the interrupt number of any pending interrupt, or 0 if no interrupts are pending. This encoding allows for up to 15 numbered interrupts. If more than one interrupt is set, then the highest priority interrupt shall be returned. Read-only, hardware-driven level status: it cannot be cleared by software and updates as pending conditions change.
        [13] IBI_DONE rw write-1-clears — IBI is done, check LAST_IBI_STATUS for result. Clear: auto-cleared by hardware when software reads STATUS.LAST_IBI_STATUS; writing 1 to this bit in INTERRUPT_STATUS also clears it.
        [12] IBI_THLD_STAT rw write-1-clears — TTI IBI Buffer Threshold Status, the Target Controller shall set this bit to 1 when the number of available entries in the TTI IBI Queue is >= the value defined in `TTI_IBI_THLD`. Clear: write 1 to this bit in INTERRUPT_STATUS (no hardware auto-clear).
        [11] RX_DESC_THLD_STAT rw write-1-clears — TTI RX Descriptor Buffer Threshold Status, the Target Controller shall set this bit to 1 when the number of available entries in the TTI RX Descriptor Queue is >= the value defined in `TTI_RX_DESC_THLD`. Clear: auto-cleared by hardware when software reads the RX Descriptor Queue; writing 1 to this bit in INTERRUPT_STATUS also clears it.
        [10] TX_DESC_THLD_STAT rw write-1-clears — TTI TX Descriptor Buffer Threshold Status, the Target Controller shall set this bit to 1 when the number of available entries in the TTI TX Descriptor Queue is >= the value defined in `TTI_TX_DESC_THLD`. Clear: write 1 to this bit in INTERRUPT_STATUS (no hardware auto-clear).
        [9] RX_DATA_THLD_STAT rw write-1-clears — TTI RX Data Buffer Threshold Status, the Target Controller shall set this bit to 1 when the number of entries in the TTI RX Data Queue is >= the value defined in `TTI_RX_DATA_THLD`. Clear: auto-cleared by hardware when software reads the RX Data Queue; writing 1 to this bit in INTERRUPT_STATUS also clears it.
        [8] TX_DATA_THLD_STAT rw write-1-clears — TTI TX Data Buffer Threshold Status, the Target Controller shall set this bit to 1 when the number of available entries in the TTI TX Data Queue is >= the value defined in `TTI_TX_DATA_THLD`. Clear: write 1 to this bit in INTERRUPT_STATUS (no hardware auto-clear).
        [3] TX_DESC_TIMEOUT rw write-1-clears — NOT IMPLEMENTED. Pending Read was NACK’ed, because the `TX_DESC_STAT` event was not handled in time. Clear: write 1 to this bit in INTERRUPT_STATUS (no hardware auto-clear).
        [2] RX_DESC_TIMEOUT rw write-1-clears — NOT IMPLEMENTED. Pending Write was NACK’ed, because the `RX_DESC_STAT` event was not handled in time. Clear: write 1 to this bit in INTERRUPT_STATUS (no hardware auto-clear).
        [1] TX_DESC_STAT rw write-1-clears — There is a pending Read Transaction on the I3C Bus. Software should write data to the TX Descriptor Queue and the TX Data Queue. Clear: write 1 to this bit in INTERRUPT_STATUS (no hardware auto-clear — writing to the TX queues does not clear it).
        [0] RX_DESC_STAT rw write-1-clears — There is a pending Write Transaction. Software should read data from the RX Descriptor Queue and the RX Data Queue. Clear: auto-cleared by hardware when software reads the RX Descriptor Queue; writing 1 to this bit in INTERRUPT_STATUS also clears it.
      0x24 INTERRUPT_ENABLE 32-bit
        [31] TRANSFER_ERR_STAT_EN — Enables the corresponding interrupt bit `TRANSFER_ERR_STAT`
        [26] TX_DESC_COMPLETE_EN — Enables the corresponding interrupt bit `TX_DESC_COMPLETE_EN`
        [25] TRANSFER_ABORT_STAT_EN — Enables the corresponding interrupt bit `TRANSFER_ABORT_STAT`
        [13] IBI_DONE_EN — Enables the corresponding interrupt bit `IBI_DONE`
        [12] IBI_THLD_STAT_EN — Enables the corresponding interrupt bit `TTI_IBI_THLD_STAT`
        [11] RX_DESC_THLD_STAT_EN — Enables the corresponding interrupt bit `TTI_RX_DESC_THLD_STAT`
        [10] TX_DESC_THLD_STAT_EN — Enables the corresponding interrupt bit `TTI_TX_DESC_THLD_STAT`
        [9] RX_DATA_THLD_STAT_EN — Enables the corresponding interrupt bit `TTI_RX_DATA_THLD_STAT`
        [8] TX_DATA_THLD_STAT_EN — Enables the corresponding interrupt bit `TTI_TX_DATA_THLD_STAT`
        [3] TX_DESC_TIMEOUT_EN — Enables the corresponding interrupt bit `TX_DESC_TIMEOUT_EN`
        [2] RX_DESC_TIMEOUT_EN — Enables the corresponding interrupt bit `RX_DESC_TIMEOUT_EN`
        [1] TX_DESC_STAT_EN — Enables the corresponding interrupt bit `TX_DESC_STAT_EN`
        [0] RX_DESC_STAT_EN — Enables the corresponding interrupt bit `RX_DESC_STAT_EN`
      0x28 INTERRUPT_FORCE 32-bit
        [31] TRANSFER_ERR_STAT_FORCE — Enables the corresponding interrupt bit `TRANSFER_ERR_STAT_FORCE`
        [26] TX_DESC_COMPLETE_FORCE — Enables the corresponding interrupt bit `TX_DESC_COMPLETE_FORCE`
        [25] TRANSFER_ABORT_STAT_FORCE — Enables the corresponding interrupt bit `TRANSFER_ABORT_STAT_FORCE`
        [13] IBI_DONE_FORCE — Enables the corresponding interrupt bit `IBI_DONE_FORCE`
        [12] IBI_THLD_FORCE — Forces the corresponding interrupt bit `TTI_IBI_THLD_STAT` to be set to 1
        [11] RX_DESC_THLD_FORCE — Forces the corresponding interrupt bit `TTI_RX_DESC_THLD_STAT` to be set to `1`
        [10] TX_DESC_THLD_FORCE — Forces the corresponding interrupt bit `TTI_TX_DESC_THLD_STAT` to be set to `1`
        [9] RX_DATA_THLD_FORCE — Forces the corresponding interrupt bit `TTI_RX_DATA_THLD_STAT` to be set to `1`
        [8] TX_DATA_THLD_FORCE — Forces the corresponding interrupt bit `TTI_TX_DATA_THLD_STAT` to be set to `1`
        [3] TX_DESC_TIMEOUT_FORCE — Enables the corresponding interrupt bit `TX_DESC_TIMEOUT_FORCE`
        [2] RX_DESC_TIMEOUT_FORCE — Enables the corresponding interrupt bit `RX_DESC_TIMEOUT_FORCE`
        [1] TX_DESC_STAT_FORCE — Enables the corresponding interrupt bit `TX_DESC_STAT_FORCE`
        [0] RX_DESC_STAT_FORCE — Enables the corresponding interrupt bit `RX_DESC_STAT_FORCE`
      0x2C TARGET_ERR_CTRL 32-bit reset 0x1FFF — Target Error Detection Control. Set bits to enable error detection. Clear to disable.
        [12] RI_INDIRECT_FIFO_OVERFLOW_ERR_DET_EN — Enable Recovery Interface INDIRECT FIFO overflow error detection and transition to Error state. Set to 0 to disable (overflow is still recorded in interrupt status).
        [11] RI_RX_FIFO_OVERFLOW_ERR_DET_EN — Enable Recovery Interface RX FIFO overflow error detection and transition to Error state. Set to 0 to disable (overflow is still recorded in interrupt status).
        [10] RI_UNSUPPORTED_ERR_DET_EN — Enable Recovery Interface unsupported command error detection. Set to 0 to disable.
        [9] RI_READONLY_ERR_DET_EN — Enable Recovery Interface write-to-read-only error detection. Set to 0 to disable.
        [8] RI_LENGTH_ERR_DET_EN — Enable Recovery Interface length error detection. Set to 0 to disable.
        [7] RI_PEC_ERR_DET_EN — Enable Recovery Interface PEC/CRC error detection. Set to 0 to disable.
        [6] FRAMING_ERR_DET_EN — Enable framing error detection. Set to 0 to disable.
        [n] TE{n}_ERR_DET_EN (n=0..5) — Enable TE{n} error detection. Set to 0 to disable.
      0x30 TARGET_ERR_INTR_STATUS 32-bit — Target Error Interrupt Status. Write 1 to clear individual bits.
        [13] RI_INDIRECT_FIFO_OVERFLOW_ERR_STAT write-1-clears — Recovery Interface INDIRECT FIFO overflow error detected
        [12] RI_RX_FIFO_OVERFLOW_ERR_STAT write-1-clears — Recovery Interface RX FIFO overflow error detected
        [11] RI_UNSUPPORTED_ERR_STAT write-1-clears — Recovery Interface unsupported command error detected
        [10] RI_READONLY_ERR_STAT write-1-clears — Recovery Interface write-to-read-only error detected
        [9] RI_LENGTH_ERR_STAT write-1-clears — Recovery Interface length mismatch error detected
        [8] RI_PEC_ERR_STAT write-1-clears — Recovery Interface PEC/CRC error detected
        [7] FRAMING_ERR_STAT write-1-clears — DA padding error (Bit[0] != 0 in SETDASA/SETNEWDA)
        [6] TE5_ERR_STAT write-1-clears — TE5: Broadcast/Direct CCC wrong R/W direction
        [5] TE4_ERR_STAT write-1-clears — TE4: ENTDAA BCR/DCR mismatch
        [4] TE3_ERR_STAT write-1-clears — TE3: ENTDAA PID mismatch
        [3] TE2_ERR_STAT write-1-clears — TE2: CCC or Private Write data parity error
        [2] TE1_ERR_STAT write-1-clears — TE1: CCC command parity error
        [1] TE0_ERR_STAT write-1-clears — TE0: Invalid reserved address + RnW combination
      0x34 TARGET_ERR_INTR_ENABLE 32-bit — Target Error Interrupt Enable. Set bits to enable corresponding interrupts.
        [13] RI_INDIRECT_FIFO_OVERFLOW_ERR_EN — Enables the corresponding interrupt bit `RI_INDIRECT_FIFO_OVERFLOW_ERR_STAT`
        [12] RI_RX_FIFO_OVERFLOW_ERR_EN — Enables the corresponding interrupt bit `RI_RX_FIFO_OVERFLOW_ERR_STAT`
        [11] RI_UNSUPPORTED_ERR_EN — Enables the corresponding interrupt bit `RI_UNSUPPORTED_ERR_STAT`
        [10] RI_READONLY_ERR_EN — Enables the corresponding interrupt bit `RI_READONLY_ERR_STAT`
        [9] RI_LENGTH_ERR_EN — Enables the corresponding interrupt bit `RI_LENGTH_ERR_STAT`
        [8] RI_PEC_ERR_EN — Enables the corresponding interrupt bit `RI_PEC_ERR_STAT`
        [7] FRAMING_ERR_EN — Enables the corresponding interrupt bit `FRAMING_ERR_STAT`
        [n+1] TE{n}_ERR_EN (n=0..5) — Enables the corresponding interrupt bit `TE{n}_ERR_STAT`
      0x38 TARGET_ERR_INTR_FORCE 32-bit — Target Error Interrupt Force. Set bits to force corresponding interrupts for testing.
        [13] RI_INDIRECT_FIFO_OVERFLOW_ERR_FORCE — Forces the corresponding interrupt bit `RI_INDIRECT_FIFO_OVERFLOW_ERR_STAT` to be set to 1
        [12] RI_RX_FIFO_OVERFLOW_ERR_FORCE — Forces the corresponding interrupt bit `RI_RX_FIFO_OVERFLOW_ERR_STAT` to be set to 1
        [11] RI_UNSUPPORTED_ERR_FORCE — Forces the corresponding interrupt bit `RI_UNSUPPORTED_ERR_STAT` to be set to 1
        [10] RI_READONLY_ERR_FORCE — Forces the corresponding interrupt bit `RI_READONLY_ERR_STAT` to be set to 1
        [9] RI_LENGTH_ERR_FORCE — Forces the corresponding interrupt bit `RI_LENGTH_ERR_STAT` to be set to 1
        [8] RI_PEC_ERR_FORCE — Forces the corresponding interrupt bit `RI_PEC_ERR_STAT` to be set to 1
        [7] FRAMING_ERR_FORCE — Forces the corresponding interrupt bit `FRAMING_ERR_STAT` to be set to 1
        [n+1] TE{n}_ERR_FORCE (n=0..5) — Forces the corresponding interrupt bit `TE{n}_ERR_STAT` to be set to 1
      {0x3C+4l} TARGET_ERR_CNT_TE{l} 32-bit (l=0..5) — Counts TE{l} errors. Saturates at 255. Write 0 to clear.
        [7:0] CNT — Error count (saturates at 255). Write 0 to clear.
      0x54 TARGET_ERR_CNT_FRAMING 32-bit — Counts framing errors. Saturates at 255. Write 0 to clear.
        [7:0] CNT — Error count (saturates at 255). Write 0 to clear.
      0x58 TARGET_ERR_CNT_RI_PEC 32-bit — Counts Recovery Interface PEC errors. Saturates at 255. Write 0 to clear.
        [7:0] CNT — Error count (saturates at 255). Write 0 to clear.
      0x5C TARGET_ERR_CNT_RI_LENGTH 32-bit — Counts Recovery Interface length mismatch errors. Saturates at 255. Write 0 to clear.
        [7:0] CNT — Error count (saturates at 255). Write 0 to clear.
      0x60 TARGET_ERR_CNT_RI_READONLY 32-bit — Counts Recovery Interface write-to-read-only errors. Saturates at 255. Write 0 to clear.
        [7:0] CNT — Error count (saturates at 255). Write 0 to clear.
      0x64 TARGET_ERR_CNT_RI_UNSUPPORTED 32-bit — Counts Recovery Interface unsupported command errors. Saturates at 255. Write 0 to clear.
        [7:0] CNT — Error count (saturates at 255). Write 0 to clear.
      0x68 TARGET_ERR_CNT_RI_RX_FIFO_OVERFLOW 32-bit — Counts Recovery Interface RX FIFO overflow errors. Saturates at 255. Write 0 to clear.
        [7:0] CNT — Error count (saturates at 255). Write 0 to clear.
      0x6C TARGET_ERR_CNT_RI_INDIRECT_FIFO_OVERFLOW 32-bit — Counts Recovery Interface INDIRECT FIFO overflow errors. Saturates at 255. Write 0 to clear.
        [7:0] CNT — Error count (saturates at 255). Write 0 to clear.
      0x70 RX_DESC_QUEUE_PORT 32-bit ro — RX Descriptor Queue Port
        [31:0] RX_DESC — RX Data
      0x74 RX_DATA_PORT 32-bit ro
        [31:0] RX_DATA
      0x78 TX_DESC_QUEUE_PORT 32-bit wo — TX Descriptor Queue Port
        [31:0] TX_DESC — TX Data
      0x7C TX_DATA_PORT 32-bit wo
        [31:0] TX_DATA
      0x80 IBI_PORT 32-bit wo — IBI Data Port
        [31:0] IBI_DATA
      0x84 QUEUE_SIZE 32-bit ro reset 0x5050404
        [31:24] TX_DATA_BUFFER_SIZE — Transmit Data Buffer Size in DWORDs calculated as `2^(N+1)`
        [23:16] RX_DATA_BUFFER_SIZE — Receive Data Buffer Size in DWORDs calculated as `2^(N+1)`
        [15:8] TX_DESC_BUFFER_SIZE — TX Descriptor Buffer Size in DWORDs calculated as `2^(N+1)`
        [7:0] RX_DESC_BUFFER_SIZE — RX Descriptor Buffer Size in DWORDs calculated as `2^(N+1)`
      0x88 IBI_QUEUE_SIZE 32-bit ro reset 0x4
        [7:0] IBI_QUEUE_SIZE — IBI Queue Size in DWORDs calculated as `2^(N+1)`
      0x8C QUEUE_THLD_CTRL 32-bit reset 0x1000101 — Queue Threshold Control
        [31:24] IBI_THLD — Controls the minimum number of IBI Queue entries needed to trigger the IBI threshold interrupt.
        [15:8] RX_DESC_THLD — Controls the minimum number of TTI RX Descriptor Queue entries needed to trigger the TTI RX Descriptor interrupt.
        [7:0] TX_DESC_THLD — Controls the minimum number of empty TTI TX Descriptor Queue entries needed to trigger the TTI TX Descriptor interrupt.
      0x90 DATA_BUFFER_THLD_CTRL 32-bit reset 0x1010101 — IBI Queue Threshold Control
        [26:24] RX_START_THLD — Minimum number of TTI RX Data queue entries of data received, in DWORDs, that will trigger the TTI RX Data interrupt. Interrupt triggers when `2^(N+1)` RX Buffer DWORD entries are received during the Read transfer.
        [18:16] TX_START_THLD — Minimum number of available TTI TX Data queue entries, in DWORDs, that will trigger the TTI TX Data interrupt. Interrupt triggers when `2^(N+1)` TX Buffer DWORD entries are available.
        [10:8] RX_DATA_THLD — Minimum number of TTI RX Data queue entries of data received, in DWORDs, that will trigger the TTI RX Data interrupt. Interrupt triggers when `2^(N+1)` RX Buffer DWORD entries are received during the Read transfer.
        [2:0] TX_DATA_THLD — Minimum number of available TTI TX Data queue entries, in DWORDs, that will trigger the TTI TX Data interrupt. Interrupt triggers when `2^(N+1)` TX Buffer DWORD entries are available.
    0x200 SoCMgmtIf group
      0x00 EXTCAP_HEADER 32-bit ro reset 0x1AC1
        fields as i3c_csr[0].I3C_EC.SecFwRecoveryIf.EXTCAP_HEADER
      0x04 SOC_MGMT_CONTROL 32-bit — SoC Management Control
        [31:0] PLACEHOLDER
      0x08 SOC_MGMT_STATUS 32-bit — SoC Management Status
        [31:0] PLACEHOLDER
      0x0C REC_INTF_CFG 32-bit — Configures the recovery interface and signals payload completion to the recovery handler.
        [1] REC_PAYLOAD_DONE — Inform Recovery Handler that payload transfer is finished.
        [0] REC_INTF_BYPASS — Choose Recovery Interface access type: * 0 - I3C Core * 1 - direct AXI
      0x10 REC_INTF_REG_W1C_ACCESS 32-bit — Mock hardware register access
        [23:16] INDIRECT_FIFO_CTRL_RESET — Write to 'Indirect memory configuration - reset' register, mocking a hardware access (bypassing 'write 1 to clear' register property).
        [15:8] RECOVERY_CTRL_ACTIVATE_REC_IMG — Write to 'Recovery Control - Activate Recovery Image' register, mocking a hardware access (bypassing 'write 1 to clear' register property).
        [7:0] DEVICE_RESET_CTRL — Write to 'Reset control - Device Reset Control' register, mocking a hardware access (bypassing 'write 1 to clear' register property).
      0x14 SOC_MGMT_RSVD_2 32-bit
        [31:0] PLACEHOLDER
      0x18 SOC_MGMT_RSVD_3 32-bit
        [31:0] PLACEHOLDER
      0x1C SOC_PAD_CONF 32-bit reset 0x1000001 — I3C Pad Configuration Register
        [31:24] PAD_TYPE — Select pad type 0 - Bidirectional 1 - Open-drain 2 - Input-only 3 - Analog input
        [7] VIRTUAL_OD_EN — Enable virtual open drain: 0 - disabled 1 - enabled
        [6] OD_EN — Enable Open-Drain: 0 - disabled 1 - enabled
        [5] IO_INVERSION — Invert I/O signal: 0 - signals pass-through 1 - signals are inverted
        [4] PULL_EN — Enable Pull: 0 - disabled 1 - enabled
        [3] PULL_DIR — Direction of the pull: 0 - Pull down 1 - Pull up
        [2] KEEPER_EN — Enable the High-Keeper: 0 - disabled 1 - enabled
        [1] SCHMITT_EN — Enable the Schmitt Trigger: 0 - disabled 1 - enabled
        [0] INPUT_ENABLE — Enable input: 0 - enabled 1 - disabled
      0x20 SOC_PAD_ATTR 32-bit reset 0xF000F00 — I3C Pad Attribute Configuration Register
        [31:24] DRIVE_STRENGTH — Select driver strength '0 - lowest '1 - highest
        [15:8] DRIVE_SLEW_RATE — Select driver slew rate '0 - lowest '1 - highest
      0x24 SOC_MGMT_FEATURE_2 32-bit
        [31:0] PLACEHOLDER — Reserved for: I/O ring and pad configuration
      0x28 SOC_MGMT_FEATURE_3 32-bit
        [31:0] PLACEHOLDER — Reserved for: I/O ring and pad configuration
      0x2C T_R_REG 32-bit
        [19:0] T_R — Rise time of both SDA and SCL in clock units
      0x30 T_F_REG 32-bit
        [19:0] T_F — Fall time of both SDA and SCL in clock units
      0x34 T_SU_DAT_REG 32-bit
        [19:0] T_SU_DAT — Data setup time in clock units
      0x38 T_SU_DAT_I2C_REG 32-bit
        [19:0] T_SU_DAT_I2C — Data setup time in I2C mode in clock units
      0x3C T_HD_DAT_REG 32-bit
        [19:0] T_HD_DAT — Data hold time in clock units
      0x40 T_HIGH_REG 32-bit
        [19:0] T_HIGH — High period of the SCL in clock units
      0x44 T_HIGH_OD_REG 32-bit
        [19:0] T_HIGH_OD — High period of the SCL in Open-Drain mode in clock units
      0x48 T_HIGH_INIT_OD_REG 32-bit
        [19:0] T_HIGH_INIT_OD — High period of the SCL in Open-Drain mode during bus initialization in clock units
      0x4C T_HIGH_I2C_REG 32-bit
        [19:0] T_HIGH_I2C — High period of the SCL in I2C mode in clock units
      0x50 T_LOW_REG 32-bit
        [19:0] T_LOW — Low period of the SCL in clock units
      0x54 T_LOW_OD_REG 32-bit
        [19:0] T_LOW_OD — Low period of the SCL in Open-Drain mode in clock units
      0x58 T_LOW_I2C_REG 32-bit
        [19:0] T_LOW_I2C — Low period of the SCL in I2C mode in clock units
      0x5C T_HD_STA_REG 32-bit
        [19:0] T_HD_STA — Hold time for START in clock units
      0x60 T_HD_STA_I2C_REG 32-bit
        [19:0] T_HD_STA_I2C — Hold time for START in I2C mode in clock units
      0x64 T_HD_RSTA_REG 32-bit
        [19:0] T_HD_RSTA — Hold time for repeated START in clock units
      0x68 T_SU_STA_REG 32-bit
        [19:0] T_SU_STA — Setup time for repeated START in clock units
      0x6C T_SU_STA_I2C_REG 32-bit
        [19:0] T_SU_STA_I2C — Setup time for repeated START in I2C mode in clock units
      0x70 T_SU_STO_REG 32-bit
        [19:0] T_SU_STO — Setup time for STOP in clock units
      0x74 T_SU_STO_I2C_REG 32-bit
        [19:0] T_SU_STO_I2C — Setup time for STOP in in I2C mode clock units
      0x78 T_DS_OD_REG 32-bit
        [19:0] T_DS_OD — Setup time for SDA during START in clock units
      0x7C T_FREE_REG 32-bit reset 0xC
        [31:0] T_FREE — Bus Free Time Between a STOP and a START
      0x80 T_FREE_I2C_REG 32-bit reset 0xC
        [31:0] T_FREE_I2C — Bus Free Time Between a STOP and a START in I2C mode
      0x84 T_AVAL_REG 32-bit reset 0x12C
        [31:0] T_AVAL
      0x88 T_IDLE_REG 32-bit reset 0xEA60
        [31:0] T_IDLE — Time in clock cycles from STOP detection until Bus Idle Condition (tIDLE). Configure based on System Clock
      0x8C HDR_TIMEOUT_EN_REG 32-bit
        [0] HDR_TIMEOUT_EN — Enable bit for the optional 60us HDR error recovery timer (I3C spec 5.1.10.1.9). When enabled, the Target can recover from TE0/TE1 errors if both SCL and SDA stay High for a period exceeding the configured threshold. Disabled on reset.
      0x90 T_HDR_TIMEOUT_REG 32-bit reset 0xEA60
        [19:0] T_HDR_TIMEOUT — Timer threshold in clock cycles for the optional HDR error recovery (I3C spec 5.1.10.1.9). If both SCL and SDA stay High for this many clock cycles during a TE0/TE1 error-induced HDR mode, the Target exits HDR mode and returns to Idle. Configure based on System Clock to achieve 60us.
    0x298 CtrlCfg group
      0x00 EXTCAP_HEADER 32-bit ro reset 0x202
        fields as i3c_csr[0].I3C_EC.SecFwRecoveryIf.EXTCAP_HEADER
      0x04 CONTROLLER_CONFIG 32-bit ro reset 0x10
        [5:4] OPERATION_MODE
    0x2A0 TERMINATION_EXTCAP_HEADER 32-bit ro reset 0x100 — Register after the last EC must advertise ID == 0. Termination register is added to guarantee that the discovery mechanism reaches termination value.
      fields as i3c_csr[0].I3C_EC.SecFwRecoveryIf.EXTCAP_HEADER

## smc_top.spm_rom_memory — Scratchpad ROM memory, present only in non-CPL configurations.
Base 0xC0040000
{0x0+8i} mem_array[{i}] (i=0..16383) reset not defined
  [63:0] data

## smc_top.spm_memory — Scratch RAM Memory - only present for non-CPL configurations
Base 0xC0060000
{0x0+8i} mem_array[{i}] (i=0..131071) reset not defined
  [63:0] data

## smc_top.smc_cla — Composite debug (DFD) MMR aperture mapping the DST sink, funnel, CLA, and DST blocks that smc_dfd_wrap instantiates.
Base 0xC0160000
0x00 dst_sink group
  0x00 Trdstramcontrol 32-bit access per field reset 0x8
    [8] Trdstramstoponwrap rw, [4] Trdstrammode rw, [3] Trdstramempty ro, [1] Trdstramenable rw, [0] Trdstramactive rw
  0x04 Trdstramimpl 32-bit access per field reset 0x1003901
    [27:24] Trdstramvendorframelength rw — Frame length in 64-byte units. Only 1, 2, 4 and 8 (64, 128, 256 and 512 bytes) are supported, and the value must match the DST's trDstVendorFrameLength.
    [13] Trdstramhassmem ro
    [12] Trdstramhassram ro
    [11:8] Trdstramcomptype ro
    [7:4] Trdstramverminor ro
    [3:0] Trdstramvermajor ro
  0x10 Trdstramstartlow 32-bit access per field
    [31:2] Trdstramstartlow rw
  0x14 Trdstramstarthigh 32-bit
  0x18 Trdstramlimitlow 32-bit access per field
    [31:2] Trdstramlimitlow rw
  0x1C Trdstramlimithigh 32-bit
  0x20 Trdstramwplow 32-bit access per field
    [31:2] Trdstramwplow rw, [0] Trdstramwrap ro
  0x24 Trdstramwphigh 32-bit
  0x28 Trdstramrplow 32-bit access per field
    [31:2] Trdstramrplow rw — Read pointer, in 32-bit words; bits [31:2] of the byte address of the word the next trDstRamData read returns. Each trDstRamData read that returns unread data advances it by one word, and from trDstRamLimitLow it wraps to trDstRamStartLow.
  0x2C Trdstramrphigh 32-bit
  0x40 Trdstramdata 32-bit ro
    [31:0] Trdstramdata — Reading launches a trace-RAM read at trDstRamRPLow. When the RAM holds unread data, the read returns that 32-bit word and advances trDstRamRPLow; otherwise the pointer does not move.
  0xFF8 ScratchLo 32-bit — Scratch register (low) for DV and potential ECO usage
    [31:0] Data
  0xFFC ScratchHi 32-bit — Scratch register (high) for DV and potential ECO usage
    [31:0] Data
0x1000 funnel group
  0x00 Trfunnelcontrol 32-bit access per field reset 0x8
    [3] Trfunnelempty ro, [1] Trfunnelenable rw, [0] Trfunnelactive rw
  0x04 Trfunnelimpl 32-bit ro reset 0x801
    [11:8] Trfunnelcomptype
    [7:4] Trfunnelverminor — e
    [3:0] Trfunnelvermajor
  0x08 Trfunneldisinput 32-bit
    [15:0] Trfunneldisinput — Bits 7:0 are reserved for N-trace srcs and 15:8 for Dst sources
  0xFF8 ScratchLo 32-bit — Scratch register (low) for DV and potential ECO usage
    [31:0] Data
  0xFFC ScratchHi 32-bit — Scratch register (high) for DV and potential ECO usage
    [31:0] Data
0x2000 cla group
  0x100 CDbgClaCounter0Cfg — Configure CLA counter0. One of the 4 counters used for counting cycles after a event match, and trigger a action on match.
    [62:48] UpperTarget
    [47:33] UpperCounter
    [32] ResetOnTarget — When Counter = {upper_target,target} reset to 0. With this bit set, counter will provide a periodic tick w/ frequency of (target +1) if the action is set to Auto Incr. The periodic tick will continue till Stop Auto Incr or Clear Counter action.
    [31:16] Target
    [15:0] Counter
  {0x100+8j} CDbgClaCounter{j}Cfg (j=1..3) — Configure CLA counter{j}. One of the 4 counters used for counting cycles after a event match, and trigger a action on match.
    [62:48] UpperTarget
    [47:33] UpperCounter
    [32] ResetOnTarget — When Counter = {upper_target,target}, reset to 0. With this bit set, counter will provide a periodic tick w/ frequency of (target +1) if the action is set to Auto Incr. The periodic tick will continue till Stop Auto Incr or Clear Counter action.
    [31:16] Target
    [15:0] Counter
  {0x120+0x10*j} CDbgNode{j}Eap0 (j=0..3) — CLA Action(s) are tied to events(s) using "event-action pairing" registers. One of the 16 EAPs (4 EAPs per Node, 4 Nodes).
    [63:58] Action3 — Select an Action
    [57:52] Action2 — Select an Action
    [51:44] Udf — User Defined Function with event type 0, 1, and 2 as arguments
    [43:38] EventType2 — Select a trigger event
    [37] CustomAction1Enable — custom_action1 is valid only if custom_action1_enable is set
    [36] CustomAction0Enable — custom_action0 is valid only if custom_action0_enable is set
    [35:32] CustomAction1 — Select the bit position of custom action bus to be set when EAP trigger is met. External blocks can define and implement the specific action for a given bit.
    [31:28] CustomAction0 — Select the bit position of custom action bus to be set when EAP trigger is met. External blocks can define and implement the specific action for a given bit.
    [27:22] EventType1 — Select a trigger event
    [21:16] EventType0 — Select a trigger event
    [15:14] LogicalOp — Relation to be satisfied among events to activate the actions
    [13:8] Action1 — Select an Action
    [7:2] Action0 — Select an Action
    [1:0] DestNode — Select Destination Node
  {0x128+0x10*j} CDbgNode{j}Eap1 (j=0..3) — CLA Action(s) are tied to events(s) using "event-action pairing" registers. One of the 16 EAPs (4 EAPs per Node, 4 Nodes).
    fields as cla.CDbgNode0Eap0
  0x160 CDbgSignalMask0Lo — Used to define debug bus match events. The positive match event (0x2) fires when debug_bus & mask = match; the negative match event (0x3) fires when debug_bus & mask != match.
    [63:0] Value — Mask to be applied to debug bus before match
  0x168 CDbgSignalMatch0Lo — Used to define debug bus match events. The positive match event (0x2) fires when debug_bus & mask = match; the negative match event (0x3) fires when debug_bus & mask != match.
    [63:0] Value — Value used for debug bus match.
  0x170 CDbgSignalMask1Lo — Used to define debug bus match events. The positive match event (0x4) fires when debug_bus & mask = match; the negative match event (0x5) fires when debug_bus & mask != match.
    [63:0] Value — Mask to be applied to debug bus before match
  0x178 CDbgSignalMatch1Lo — Used to define debug bus match events. The positive match event (0x4) fires when debug_bus & mask = match; the negative match event (0x5) fires when debug_bus & mask != match.
    [63:0] Value — Value used for debug bus match.
  0x180 CDbgSignalEdgeDetectCfg — Register to configure debug bus for edge triggers.
    [15] PosEdgeSignal1 — Defines which edge to detect for singal from signal1_select. 1: Pos edge, 0: Neg Edge
    [14:8] Signal1Select — Define which signal to select for edge detection.
    [7] PosEdgeSignal0 — Defines which edge to detect for singal from signal0_select. 1: Pos edge, 0: Neg Edge
    [6:0] Signal0Select — Define which signal to select for edge detection.
  0x188 CDbgEapStatus access per field — Register to indicate if an EAP was activated. There is one status bit per EAP in bits [15:0] (Node0Eap0..Node3Eap3, 4 EAPs per Node across 4 Nodes) and one write-to-clear bit per EAP in bits [47:32] (Node0Eap0W2C..Node3Eap3W2C); write the matching w2c bit to reset a status bit. The register is used by SW to know if an action was taken (ex: NMI ISR needs to know which of the EAP triggered the NMI)
    [4n+35] Node{n}Eap3W2C rw (n=0..3), [4n+34] Node{n}Eap2W2C rw (n=0..3), [4n+33] Node{n}Eap1W2C rw (n=0..3), [4n+32] Node{n}Eap0W2C rw (n=0..3), [4n+3] Node{n}Eap3 ro (n=0..3), [4n+2] Node{n}Eap2 ro (n=0..3), [4n+1] Node{n}Eap1 ro (n=0..3), [4n] Node{n}Eap0 ro (n=0..3)
  0x190 CDbgClaCtrlStatus access per field reset 0x1B00 — Ctrl/Status register to Enable EAP after EAP programming is complete, and read the current node.
    [63] ClaLock rw — If this bit is set, then CLA is locked and the enable_cla is latched forever
    [15] DisableLocalClockHalt rw — If this bit is set, clock halt action is not applied to local clocks
    [14] DisableGlobalClockHalt rw — If this bit is set, clock halt action is not applied to global clocks
    [13:7] ClaChainLoopDelay rw — Self-filter delay, in CLA clock cycles, for the CLA's own cross-triggers. When an EAP action drives cross-trigger output n, the CLA ignores incoming cross-trigger n for one cycle, ClaChainLoopDelay cycles later, so that its own trigger returning through the cross-trigger network does not retrigger it; with 0 it ignores the input in the same cycle. A further own trigger while the delay counts does not restart it. Incoming clock halt is not filtered.
    [6] EnableCla rw — Set this bit to 1 to enable the CLA functional clock; clear it to 0 to gate that clock (save pwr). The CLA register block runs on a clock whose functional enable is tied high, so this bit can still be written while the functional clock is gated
    [5] EnableEap rw — Set Enable EAP to 1 after EAP programming is complete
    [1:0] CurrentNode ro — Read the current node.
  0x198 CDbgMuxSelLo — Mode, ID, fine-grain time enable and lane selects for the CLA debug-bus mux, which builds the four 16-bit lanes of the CLA's 64-bit debug bus from 16 input segments. The mux ID is 0: the mode is taken while DbmId is 0, and the lane selects while DbmId is 0 and DbmMode is 1.
    [6n+21:6n+16] Muxselseg{n} (n=4..7) — No effect in the SMC: the CLA debug-bus mux has four output lanes, selected by Muxselseg0 to Muxselseg3.
    [39:34] Muxselseg3 — Binary segment select for lane 3 of the CLA debug bus, bits [63:48]. The input segments are 16 bits wide: Seg0 = input bits [15:0], Seg1 = [31:16], and so on to Seg15. 0 selects Seg3; a value k from 1 to 12 selects Seg(k+3), so 1 selects Seg4 and 4 selects Seg7; 13 to 63 drive zero. When FineGrainTime is set, the fine-grain time counter is inserted below Seg0: 0 selects Seg2, and k from 1 to 13 selects Seg(k+2).
    [33:28] Muxselseg2 — Binary segment select for lane 2 of the CLA debug bus, bits [47:32]. The input segments are 16 bits wide: Seg0 = input bits [15:0], Seg1 = [31:16], and so on to Seg15. 0 selects Seg2; a value k from 1 to 12 selects Seg(k+3), so 1 selects Seg4 and 4 selects Seg7; 13 to 63 drive zero. When FineGrainTime is set, the fine-grain time counter is inserted below Seg0: 0 selects Seg1, and k from 1 to 13 selects Seg(k+2).
    [27:22] Muxselseg1 — Binary segment select for lane 1 of the CLA debug bus, bits [31:16]. The input segments are 16 bits wide: Seg0 = input bits [15:0], Seg1 = [31:16], and so on to Seg15. 0 selects Seg1; a value k from 1 to 12 selects Seg(k+3), so 1 selects Seg4 and 4 selects Seg7; 13 to 63 drive zero. When FineGrainTime is set, the fine-grain time counter is inserted below Seg0: 0 selects Seg0, and k from 1 to 13 selects Seg(k+2).
    [21:16] Muxselseg0 — Binary segment select for lane 0 of the CLA debug bus, bits [15:0]. The input segments are 16 bits wide: Seg0 = input bits [15:0], Seg1 = [31:16], and so on to Seg15. 0 selects Seg0; a value k from 1 to 12 selects Seg(k+3), so 1 selects Seg4 and 4 selects Seg7; 13 to 63 drive zero. When FineGrainTime is set, the fine-grain time counter is inserted below Seg0: 0 selects the fine-grain time counter, and k from 1 to 13 selects Seg(k+2).
    [8] Finegraintime — Fine Grain Time Enable. If this bit is set, the fine grain time is enabled.
    [7:2] Dbmid — Unique DBM ID of the DBM instance
    [1:0] Dbmmode — Mode selection, 0: DBM off, 1: Normal debug mode, 2: DBM ID output mode, 3: Toggle Mode
  0x1A0 CDbgRsvd1 — Reserved Register that can be changed.
    [63:0] Value — Value of reserved register.
  0x1A8 CDbgRsvd2 — Reserved Register that can be changed.
    [63:0] Value — Value of reserved register.
  0x1B0 CDbgTransitionMaskLo — 3 registers to configure "transition event". This register is to select the signals of interest using a mask.
    [63:0] Value
  0x1B8 CDbgTransitionFromValueLo — 3 registers to configure "transition event". The event is triggered on transition from Value A to Value B. This register specifies Value A.
    [63:0] Value
  0x1C0 CDbgTransitionToValueLo — 3 registers to configure "transition event". The event is triggered on transition from Value A to Value B. This register specifies Value B.
    [63:0] Value
  0x1C8 CDbgOnesCountMaskLo — 2 registers to configure "ones count" event. This register is to select the signals of interest using a mask.
    [63:0] Value
  0x1D0 CDbgOnesCountValue — 2 registers to configure "ones count" event. Event triggered when the sum of the signals match the value specified in this register.
    [63:0] Value
  0x1D8 CDbgAnyChangeLo — Event triggered when a subset of debug signals change. The mask is used to select the subset of the debug signals.
    [63:0] Mask
  {0x1E0+0x10*j} CDbgSignalSnapshotNode{j}Eap0Lo ro (j=0..3) — debug Bus Value when Node{j} Eap0 Trigger is met.
    [63:0] Value
  {0x1E8+0x10*j} CDbgSignalSnapshotNode{j}Eap1Lo ro (j=0..3) — debug Bus Value when Node{j} Eap1 Trigger is met.
    [63:0] Value
  0x220 CDbgClaTimeMatch — This value is compared (greater than or equal to the programmed value) against the internal time register value of the core, and is used to generate a time match event for CLA. Needs to be non zero for the time match event signal to trigger. The event will only trigger an action if the EAP programming is done. Requires writing 0 to this register to stop the match event.
    [63:0] TimeMatchVal
  0x228 CDbgSignalMask2Lo — Used to define debug bus match events. The positive match event (0x1C) fires when debug_bus & mask = match; the negative match event (0x1D) fires when debug_bus & mask != match.
    [63:0] Value — Mask to be applied to debug bus before match
  0x230 CDbgSignalMatch2Lo — Used to define debug bus match events. The positive match event (0x1C) fires when debug_bus & mask = match; the negative match event (0x1D) fires when debug_bus & mask != match.
    [63:0] Value — Value used for debug bus match.
  0x238 CDbgSignalMask3Lo — Used to define debug bus match events. The positive match event (0x1E) fires when debug_bus & mask = match; the negative match event (0x1F) fires when debug_bus & mask != match.
    [63:0] Value — Mask to be applied to debug bus before match
  0x240 CDbgSignalMatch3Lo — Used to define debug bus match events. The positive match event (0x1E) fires when debug_bus & mask = match; the negative match event (0x1F) fires when debug_bus & mask != match.
    [63:0] Value — Value used for debug bus match.
  {0x248+0x10*j} CDbgNode{j}Eap2 (j=0..3) — CLA Action(s) are tied to events(s) using "event-action pairing" registers. One of the 16 EAPs (4 EAPs per Node, 4 Nodes).
    fields as cla.CDbgNode0Eap0
  {0x250+0x10*j} CDbgNode{j}Eap3 (j=0..3) — CLA Action(s) are tied to events(s) using "event-action pairing" registers. One of the 16 EAPs (4 EAPs per Node, 4 Nodes).
    fields as cla.CDbgNode0Eap0
  {0x288+0x10*j} CDbgSignalSnapshotNode{j}Eap2Lo ro (j=0..3) — debug Bus Value when Node{j} Eap2 Trigger is met.
    [63:0] Value
  {0x290+0x10*j} CDbgSignalSnapshotNode{j}Eap3Lo ro (j=0..3) — debug Bus Value when Node{j} Eap3 Trigger is met.
    [63:0] Value
  0x2C8 CDbgSignalDelayMuxSel
    [2n+1:2n] Muxselseg{n} (n=8..15) — Dbg Mux Shifted signals Select Bits for Lane 0
    [2n+1:2n] Muxselseg{n} (n=0..7) — Dbg Mux Shifted signals Select Bits for Lane {n}
  0x2D8 CDbgClaXtriggerTimestretch — This value determines the time stretched pulse duration for the cross trigger. 8 bits for each of the two triggers.
    [15:8] Xtrigger1Stretch, [7:0] Xtrigger0Stretch
  0x2F0 CDbgClaTimestamp — 64-bit timestamp counter. Increments on time_tick. Can be written directly or loaded from timestamp_sync on xtrigger when resync is enabled.
    [63:8] TimestampUpper — Current timestamp value (upper 56 bits)
    [7:0] TimestampLower — Current timestamp value (lower 8 bits)
  0x2F8 CDbgClaTimestampSync — Timestamp sync value. This value is loaded into the timestamp register on xtrigger posedge when resync bit is enabled.
    [63:0] TimestampSync — Sync value to load into timestamp
  0x300 CDbgClaTimestampConfig — Timestamp configuration register. Controls resync behavior and debug marker.
    [9] TsCapture — When this bit is set, a cross trigger 0 event will cause the value from Timestamp register to be written into the TimestampCapture register. No effect in the SMC, where the CLA timestamp counts the local time tick (timestamp scheme 0).
    [8:1] DebugMarker — Debug marker output value
    [0] Resync — When set, timestamp is loaded from timestamp_sync on xtrigger posedge. Auto-clears after load.
  0x308 CDbgClaTimestampOffset — Timestamp offset register. The Offset value is subtracted from the timestamp before comparing with incoming timestamp value. No effect in the SMC, where the CLA timestamp counts the local time tick (timestamp scheme 0).
    [55:0] Offset — Timestamp offset value. No effect in the SMC.
  0x400 CDbgSignalMask0Hi — Used to define debug bus match events. The positive match event (0x2) fires when debug_bus & mask = match; the negative match event (0x3) fires when debug_bus & mask != match. No effect in the SMC, whose CLA evaluates a 64-bit debug bus; only the Lo register is used.
    [63:0] Value — Mask to be applied to debug bus before match
  0x408 CDbgSignalMatch0Hi — Used to define debug bus match events. The positive match event (0x2) fires when debug_bus & mask = match; the negative match event (0x3) fires when debug_bus & mask != match. No effect in the SMC, whose CLA evaluates a 64-bit debug bus; only the Lo register is used.
    [63:0] Value — Value used for debug bus match.
  0x410 CDbgSignalMask1Hi — Used to define debug bus match events. The positive match event (0x4) fires when debug_bus & mask = match; the negative match event (0x5) fires when debug_bus & mask != match. No effect in the SMC, whose CLA evaluates a 64-bit debug bus; only the Lo register is used.
    [63:0] Value — Mask to be applied to debug bus before match
  0x418 CDbgSignalMatch1Hi — Used to define debug bus match events. The positive match event (0x4) fires when debug_bus & mask = match; the negative match event (0x5) fires when debug_bus & mask != match. No effect in the SMC, whose CLA evaluates a 64-bit debug bus; only the Lo register is used.
    [63:0] Value — Value used for debug bus match.
  0x420 CDbgSignalMask2Hi — Used to define debug bus match events. The positive match event (0x1C) fires when debug_bus & mask = match; the negative match event (0x1D) fires when debug_bus & mask != match. No effect in the SMC, whose CLA evaluates a 64-bit debug bus; only the Lo register is used.
    [63:0] Value — Mask to be applied to debug bus before match
  0x428 CDbgSignalMatch2Hi — Used to define debug bus match events. The positive match event (0x1C) fires when debug_bus & mask = match; the negative match event (0x1D) fires when debug_bus & mask != match. No effect in the SMC, whose CLA evaluates a 64-bit debug bus; only the Lo register is used.
    [63:0] Value — Value used for debug bus match.
  0x430 CDbgSignalMask3Hi — Used to define debug bus match events. The positive match event (0x1E) fires when debug_bus & mask = match; the negative match event (0x1F) fires when debug_bus & mask != match. No effect in the SMC, whose CLA evaluates a 64-bit debug bus; only the Lo register is used.
    [63:0] Value — Mask to be applied to debug bus before match
  0x438 CDbgSignalMatch3Hi — Used to define debug bus match events. The positive match event (0x1E) fires when debug_bus & mask = match; the negative match event (0x1F) fires when debug_bus & mask != match. No effect in the SMC, whose CLA evaluates a 64-bit debug bus; only the Lo register is used.
    [63:0] Value — Value used for debug bus match.
  0x440 CDbgMuxSelHi — No effect in the SMC. The CLA debug-bus mux has four output lanes and takes its mode, ID, fine-grain time enable and lane selects from CDbgMuxSelLo.
    [6n-27:6n-32] Muxselseg{n} (n=8..15) — No effect in the SMC.
    [7:2] Dbmid — No effect in the SMC.
    [1:0] Dbmmode — No effect in the SMC.
  0x448 CDbgTransitionMaskHi — 3 registers to configure "transition event". This register is to select the signals of interest using a mask. No effect in the SMC, whose CLA evaluates a 64-bit debug bus; only the Lo register is used.
    [63:0] Value
  0x450 CDbgTransitionFromValueHi — 3 registers to configure "transition event". The event is triggered on transition from Value A to Value B. This register specifies Value A. No effect in the SMC, whose CLA evaluates a 64-bit debug bus; only the Lo register is used.
    [63:0] Value
  0x458 CDbgTransitionToValueHi — 3 registers to configure "transition event". The event is triggered on transition from Value A to Value B. This register specifies Value B. No effect in the SMC, whose CLA evaluates a 64-bit debug bus; only the Lo register is used.
    [63:0] Value
  0x460 CDbgOnesCountMaskHi — 2 registers to configure "ones count" event. This register is to select the signals of interest using a mask. No effect in the SMC, whose CLA evaluates a 64-bit debug bus; only the Lo register is used.
    [63:0] Value
  0x468 CDbgAnyChangeHi — Event triggered when a subset of debug signals change. The mask is used to select the subset of the debug signals. No effect in the SMC, whose CLA evaluates a 64-bit debug bus; only the Lo register is used.
    [63:0] Mask
  {0x470+0x10*j} CDbgSignalSnapshotNode{j}Eap0Hi ro (j=0..3) — debug Bus Value when Node{j} Eap0 Trigger is met. Never captured in the SMC, whose CLA evaluates a 64-bit debug bus.
    [63:0] Value
  {0x478+0x10*j} CDbgSignalSnapshotNode{j}Eap1Hi ro (j=0..3) — debug Bus Value when Node{j} Eap1 Trigger is met. Never captured in the SMC, whose CLA evaluates a 64-bit debug bus.
    [63:0] Value
  {0x4B0+0x10*j} CDbgSignalSnapshotNode{j}Eap2Hi ro (j=0..3) — debug Bus Value when Node{j} Eap2 Trigger is met. Never captured in the SMC, whose CLA evaluates a 64-bit debug bus.
    [63:0] Value
  {0x4B8+0x10*j} CDbgSignalSnapshotNode{j}Eap3Hi ro (j=0..3) — debug Bus Value when Node{j} Eap3 Trigger is met. Never captured in the SMC, whose CLA evaluates a 64-bit debug bus.
    [63:0] Value
  0x4F0 CDbgLfsr — LFSR value.
    [63:1] Lfsr — Value of the LFSR register.
    [0] LfsrActive — Enable the LFSR register.
  0x4F8 CDbgLfsrMask — LFSR programming mask.
    [63:1] Mask — Value to mask the LFSR register.
  0x500 CDbgTimestampCapture ro — Captured timestamp upper bits. When ts_capture is set in the timestamp config register, a cross trigger 0 event captures the timestamp upper bits into this register. Never captured in the SMC, where the CLA timestamp counts the local time tick (timestamp scheme 0).
    [63:0] Timestamp — Timestamp capture value.
  {0x508+0x10*j} CDbgCompare{j}Lo (j=0..3) — Value for arithmetic comparison.
    [63:0] Value
  {0x510+0x10*j} CDbgCompare{j}MaskLo (j=0..3) — Value to mask the arithmetic comparison.
    [63:0] Value
  {0x548+0x10*j} CDbgCompare{j}Hi (j=0..3) — Value for arithmetic comparison. No effect in the SMC, whose CLA evaluates a 64-bit debug bus; only the Lo register is used.
    [63:0] Value — Value for arithmetic comparison.
  {0x550+0x10*j} CDbgCompare{j}MaskHi (j=0..3) — Value to mask the arithmetic comparison. No effect in the SMC, whose CLA evaluates a 64-bit debug bus; only the Lo register is used.
    [63:0] Value — Value to mask the arithmetic comparison.
  0xFF8 Scratch — Additional scratch register for DV and potential ECO usage
    [63:0] Data
0x3000 dst group
  0x00 Trdstcontrol 32-bit access per field reset 0x3000068
    [26:24] Trdstformat rw — bit[0]: XOR Enable, bit[1]: VLT Enable. Supported values : 2'b3 (XOR+VLT Compression), 2'b1 (XOR Compresion), 2'b0 (No Compression)
    [23:20] Trdstsyncmax rw — When trDstSyncMode is set to 2'b10, timestamp will be sent for every 2^(trDstSyncMax + 4) Cluster clocks.
    [17:16] Trdstsyncmode rw — Periodic sync mode. 2'b00: off. 2'b01: stream counting, with trDstVendorStreamLength frames between non-compressed packets. 2'b10: send a timestamp packet every 2^(trDstSyncMax + 4) Cluster clocks. 2'b11: no effect, as 2'b00.
    [15] Trdstinhibitsrc ro
    [13] Trdstinststallena ro
    [12] Trdstinststalloroverflow ro
    [11] Trdstinsttriggerenable rw
    [9] Trdstcontext ro
    [6:4] Trdstinstmode ro
    [3] Trdstempty ro
    [2] Trdstinsttracing rw
    [1] Trdstenable rw
    [0] Trdstactive rw
  0x04 Trdstimpl 32-bit access per field reset 0x41010101
    [31] Trdsttimestampconfig rw — DST timestamp configuration. 0: timestamp input form external source (CoreTime). 1: timestamp from CLA timesync.
    [30:28] Trdstvendorstreamlength rw — Specify Stream length. A stream starts with "no compressed packet". Stream length specifies number of frames before a non-compressed packet is sent, and applies only when trDstSyncMode is 2'b01. Values 0 to 4 give Stream Length = 32* 2^trDstVendorStreamLength (32 to 512 frames); values 5 to 7 give 32.
    [27:24] Trdstvendorframelength rw — Specify frame length. Frame Length = trDstVendorFrameLength* 64 bytes; Frame Length should be a multiple of Bank Data Width. Only 1, 2, 4 and 8 (64, 128, 256 and 512 bytes) are supported, because the DST sink finds frame boundaries at the power of two given by the highest set bit of its frame length. Program the sink's trDstRamVendorFrameLength with the same value.
    [23:20] Trdstprotocolminor ro
    [19:16] Trdstprotocolmajor ro
    [11:8] Trdstcomptype ro
    [7:4] Trdstverminor ro
    [3:0] Trdstvermajor ro
  0x08 Trdstinstfeatures 32-bit access per field reset 0x40000000
    [31:28] Trdstsrcbits rw
    [27:16] Trdstsrcid rw — Source ID sent in the trace packet headers. Only bits [3:0] are used.
    [8] Trdstinstenrepeatedhistory ro
    [1] Trdstinstnotrapaddr ro
    [0] Trdstinstnoaddrdiff ro
  0x1A0 CDbgDebugTraceCfg 32-bit reset 0x102810
    [21] FrameClosureMode — Closure Mode: 1: Close frame with a packet no larger than max packet size before any overflow (due to packets crossing frame boundary). 0: Close frame when packets cross boundary. Push back packet crossing frame boundary to packet generator.
    [20] FrameModeEnable — Enable Frame Mode (Frame Mode: Always pack "frame length" number of bytes for trace transmission). If flush to memory is stalled (due to silicon bug), we can have incomplete packets in memory. Frame Mode will help SW decoder to avoid reading incomplete trasnmitted packets. In Frame Mode, SW will get a memory pointer that is aligned to Frame Length. HW will ensure there are no incomplete packets incluced in the region pointed by memory pointer.
    [15:12] FrameLenghtInBytes — Use trDstImpl[trDstVendorFrameLength] for Frame Length programming. Register field ZBB-ed.
    [11:4] TraceFrameFillByte — Use "Filler Packet" to align a stream of trace packets within a frame boundary.
    [3:0] TraceSourceId — Stored but not used. The trace packet headers carry trDstInstFeatures[trDstSrcID].
  0xFF8 ScratchLo 32-bit — Scratch register (low) for DV and potential ECO usage
    [31:0] Data
  0xFFC ScratchHi 32-bit — Scratch register (high) for DV and potential ECO usage
    [31:0] Data

## smc_top.smc_external — Adopter-provided external register window, split into mandatory and supplementary regions.
Base 0xC0400000
0x00 mandatory group — Mandatory adopter blocks in the external window: eFuse shim, per-pad GPIO control, PLL, and configuration straps.
  0x00 efuse_shim_ctrl group — DV model of the eFuse SHIM control interface.
    0x00 EFUSE_BANK_INIT_TIME 32-bit reset 0x20 — eFuse bank initialization time. Number of cycles to wait for the OTP macro to initialize before sensing can begin.
      [31:0] init_time — Most OTP have a initialization time before sensing can be done
  0x3000 straps group — Configuration strap values. How they are captured is adopter-defined.
    0x00 STRAPS_LO 32-bit ro
      [31:0] straps — Configuration straps 0 - 31. Bits 0 - 10, 16, 17, 24 and 27 - 31 have no strap assigned; no strap function consumes them. Strap assignments in this range: * bit 11: CHIP_ID[3] - CHIP_ID is the I2C/I3C static address strap * bit 12: CHIP_ID[2] - CHIP_ID is the I2C/I3C static address strap * bit 13: BYPASS_SRAM_REPAIR - Bypass the memory repair process * bit 14: TEST_EN - Enable DFT test mode * bit 15: CHIP_ID[1] - CHIP_ID is the I2C/I3C static address strap * bit 18: BOOT_I2C - Default alternate boot channel is I3C0 and can be reconfigured to use I2C0 * bit 19: BOOT_RECOVERY - Use I3C0 for BL1 boot image loading instead of the SPI channel * bit 20: BL0_PLLCLK - Use the PLL generated clock by default in BL0, and override to use the reference clock when this strap is asserted * bit 21: STATUS_RPT_DISABLE - Disable BL0 status reporting. It is on by default * bit 22: SPI_USE_FUSED_CONFIG - Use the SPI configuration values stored in the fuse field * bit 23: CHIP_ID[0] - CHIP_ID is the I2C/I3C static address strap * bit 25: PRIMARY_CHIPLET - Identifies the primary chiplet, the boot master * bit 26: SRAM_AUTO_ZERO_DISABLE - Disable auto zero of the SMC SRAM when asserted
    0x04 STRAPS_HI 32-bit ro
      [30:0] straps — Configuration straps 32 - 62. All bits other than those listed below have no strap assigned; no strap function consumes them. Strap assignments in this range: * bit 22: MBIST_BYPASS - Ignore results of Power-On MBIST for boot * bit 26: ROTATE_UPDATE - Swaps primary and backup image in SEP BL0 ROM
0x4000 supplementary group — Supplementary adopter blocks in the external window: extra controllers, extra GPIO registers, and PVT.

## smc_top.mmode_region — Address region whose accesses an output remap redirects.
Base 0xC1000000
Same registers: smc_top.xvisor_region 0xC1800000
{0x0+8i} mem_array[{i}] (i=0..1048575) reset not defined
  [63:0] data

## smc_top.smc_cluster_plic — Platform-Level Interrupt Controller register interface.
Base 0xC4000000
{0x0+4i} PRIORITY[{i}] (i=0..336) 32-bit reset not defined
  [2:0] value — Priority of interrupt. The higher the set value, the higher the priority. For interrupts with the same priority, the tie is broken by interrupt ID; interrupts with the lowest ID has highest effective priority. Interrupts start counting at 1.
{0x1000+4i} PENDING[{i}] (i=0..10) 32-bit ro
  [31:0] value — Set to 1 if interrupt source 1 is pending, regardless of its enable or priority setting. Interrupts start counting at 1.
{0x2000+4i} CORE0_MEIP_ENABLE[{i}] (i=0..10) 32-bit reset not defined
  [31:0] value — Set bits to 1 if interrupt should be enabled. Interrupts start counting at 1.
{0x2080+4i} CORE1_MEIP_ENABLE[{i}] (i=0..10) 32-bit reset not defined
  fields as CORE0_MEIP_ENABLE[0]
{0x2100+4i} CORE2_MEIP_ENABLE[{i}] (i=0..10) 32-bit reset not defined
  fields as CORE0_MEIP_ENABLE[0]
{0x2180+4i} CORE3_MEIP_ENABLE[{i}] (i=0..10) 32-bit reset not defined
  fields as CORE0_MEIP_ENABLE[0]
{0x2200+4i} CORE0_SEIP_ENABLE[{i}] (i=0..10) 32-bit reset not defined
  fields as CORE0_MEIP_ENABLE[0]
{0x2280+4i} CORE1_SEIP_ENABLE[{i}] (i=0..10) 32-bit reset not defined
  fields as CORE0_MEIP_ENABLE[0]
{0x2300+4i} CORE2_SEIP_ENABLE[{i}] (i=0..10) 32-bit reset not defined
  fields as CORE0_MEIP_ENABLE[0]
{0x2380+4i} CORE3_SEIP_ENABLE[{i}] (i=0..10) 32-bit reset not defined
  fields as CORE0_MEIP_ENABLE[0]
{0x200000+0x1000*i} CORE{i}_MEIP_THRESHOLD 32-bit reset not defined (i=0..3)
  [2:0] value — Interrupt notification threshold. Maximum value is 7. The context's external interrupt is raised only while the highest-priority pending, enabled source has a priority strictly greater than the threshold. The threshold does not gate claims: a claim read returns the highest-priority pending, enabled source regardless of the threshold.
{0x200004+0x1000*i} CORE{i}_MEIP_CLAIM_COMPLETE 32-bit reset not defined (i=0..3)
  [31:0] value — Claim/Complete register. Reading this register returns the claimed interrupt number and makes it no longer pending. Writing the interrupt number back completes the interrupt.
{0x204000+0x1000*i} CORE{i}_SEIP_THRESHOLD 32-bit reset not defined (i=0..3)
  fields as CORE0_MEIP_THRESHOLD
{0x204004+0x1000*i} CORE{i}_SEIP_CLAIM_COMPLETE 32-bit reset not defined (i=0..3)
  fields as CORE0_MEIP_CLAIM_COMPLETE

## smc_top.smc_cluster_clint — Core-Local Interruptor: software-interrupt, timer-compare, and machine-time registers.
Base 0xC8000000
{0x0+4i} MSIP[{i}] (i=0..3) 32-bit access per field
  [0] value rw — MSIP bit for core
{0x4000+8i} MTIMECMP[{i}] (i=0..3) reset not defined
  [63:0] count — Timer compare value. The core's machine timer interrupt is asserted while MTIME is greater than or equal to this value, and deasserts when software sets this value above MTIME. This register has no reset: its value, and therefore the level of the machine timer interrupt, is undefined until software writes it. Write it before enabling the machine timer interrupt.
0xBFF8 MTIME
  [63:0] count — Machine time. Increments by one every 1000 CPU-cluster cbus clock cycles. A software write takes precedence over an increment in the same cycle.

## smc_top.smc_cluster_core0_beu — Status registers reporting correctable and uncorrectable I-cache, D-cache, and TileLink bus errors.
Base 0xC8010000
Same registers: smc_top.smc_cluster_core1_beu 0xC8011000, smc_top.smc_cluster_core2_beu 0xC8012000, smc_top.smc_cluster_core3_beu 0xC8013000
0x00 CAUSE
  [2:0] data — Cause register. Enumerates different kinds of errors
    0=no_error; 1=itl_error (ICache tilelink bus error); 2=iec_error (ICache ECC correctable error); 3=ieu_error (ICache ECC uncorrectable error); 5=dtl_error (DCache tilelink bus error); 6=dec_error (DCache ECC correctable error); 7=deu_error (DCache ECC uncorrectable error)
0x08 PHYS_ADDR reset not defined
  [55:0] value — Physical address captured with CAUSE when an enabled error arrives and CAUSE is zero. Software may overwrite the value; writes take priority over capture. No reset value
0x10 ENABLE reset 0xE6
  [7] dcache_uncorrectable — Enable recording error information for DCache ECC uncorrectable bus error. Enabled on reset.
  [6] dcache_correctable — Enable recording error information for DCache ECC correctable bus error. Enabled on reset.
  [5] dcache_tlbus — Enable recording error information for DCache Tilelink bus error. Enabled on reset.
  [2] icache_correctable — Enable recording error information for ICache ECC correctable bus error. Enabled on reset.
  [1] icache_tlbus — Enable recording error information for ICache Tilelink bus error. Enabled on reset.
0x18 PLIC_ENABLE
  [7] dcache_uncorrectable — PLIC interrupt enable mask for DCache ECC uncorrectable bus error.
  [6] dcache_correctable — PLIC interrupt enable mask for DCache ECC correctable bus error.
  [5] dcache_tlbus — PLIC interrupt enable mask for DCache Tilelink bus error.
  [2] icache_correctable — PLIC interrupt enable mask for ICache ECC correctable bus error.
  [1] icache_tlbus — PLIC interrupt enable mask for ICache Tilelink bus error.
0x20 ACCRUED_ENABLE — Sticky accrued error status. The legacy name ACCRUED_ENABLE does not denote an enable mask. Error events set these bits independently of ENABLE. Ordinary software writes replace the bits (write zero to clear) and take priority over simultaneous events. PLIC_ENABLE and LOCAL_ENABLE mask this status for interrupt delivery.
  [7] dcache_uncorrectable — Sticky accrued status for DCache ECC uncorrectable bus error.
  [6] dcache_correctable — Sticky accrued status for DCache ECC correctable bus error.
  [5] dcache_tlbus — Sticky accrued status for DCache Tilelink bus error.
  [2] icache_correctable — Sticky accrued status for ICache ECC correctable bus error.
  [1] icache_tlbus — Sticky accrued status for ICache Tilelink bus error.
0x28 LOCAL_ENABLE
  [7] dcache_uncorrectable — Core local interrupt enable mask for DCache ECC uncorrectable bus error.
  [6] dcache_correctable — Core local interrupt enable mask for DCache ECC correctable bus error.
  [5] dcache_tlbus — Core local interrupt enable mask for DCache Tilelink bus error.
  [2] icache_correctable — Core local interrupt enable mask for ICache ECC correctable bus error.
  [1] icache_tlbus — Core local interrupt enable mask for ICache Tilelink bus error.

## smc_top.smc_cluster_error_device — Error responder. Every read or write in this region completes with a bus error; no storage is present.
Base 0xC8014000
{0x0+4i} mem_array[{i}] (i=0..1023) 32-bit reset not defined
  [31:0] data

## Notices in the file
SPDX-License-Identifier: Apache-2.0
SPDX-FileCopyrightText: 2026 Tenstorrent USA, Inc.
